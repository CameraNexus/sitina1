File: Hardware/mainboard/ccd_power.kicad_sch (KiCad schematic)
At the start: 100 parts, among them U1201 TPS65130RGE, U1202 TPS65130RGE, U1203 LT1964-BYP, U1204 TPS65130RGE, U1205 LT3023

Commit message: Use dedicated LDO for 1.5V rail
Parts:
- added C32 (x2): 1uF, Capacitor_SMD:C_0402_1005Metric, symbol Device:C
- added U503: XC6206P152MR, Package_TO_SOT_SMD:SOT-23-3, symbol Regulator_Linear:XC6206PxxxMR
Connections:
- net GND: now also C32.2, C32.2, U503.1 (GND)
- new net +1V5: C32.1, U503.2 (VO)
- new net +2V: C32.1, U503.3 (VI)
Changed lines of the file:
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@@
   (junction (at 30.48 114.3) (diameter 0) (color 0 0 0 0)
   )
+  (junction (at 147.32 171.45) (diameter 0) (color 0 0 0 0)
+  )
   (junction (at 43.18 116.84) (diameter 0) (color 0 0 0 0)
   )
@@
   (junction (at 96.52 33.02) (diameter 0) (color 0 0 0 0)
   )
+  (junction (at 137.16 163.83) (diameter 0) (color 0 0 0 0)
+  )
   (junction (at 187.96 104.14) (diameter 0.9144) (color 0 0 0 0)
   )
@@
   )
   (junction (at 76.2 132.08) (diameter 0) (color 0 0 0 0)
+  )
+  (junction (at 157.48 163.83) (diameter 0) (color 0 0 0 0)
   )
   (junction (at 148.59 48.26) (diameter 0) (color 0 0 0 0)
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 137.16 163.83) (xy 139.7 163.83))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 148.59 60.96) (xy 151.13 60.96))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 137.16 171.45) (xy 147.32 171.45))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 241.3 73.66) (xy 243.84 73.66))
     (stroke (width 0) (type solid))
@@
     (stroke (width 0) (type solid))
   )
+  (wire (pts (xy 137.16 161.29) (xy 137.16 163.83))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 59.69 93.98) (xy 68.58 93.98))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type solid))
   )
+  (wire (pts (xy 157.48 161.29) (xy 157.48 163.83))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 86.36 119.38) (xy 96.52 119.38))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 147.32 171.45) (xy 157.48 171.45))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 30.48 114.3) (xy 45.72 114.3))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 157.48 163.83) (xy 154.94 163.83))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 260.35 43.18) (xy 262.89 43.18))
     (stroke (width 0) (type default))
@@
   (wire (pts (xy 152.4 137.16) (xy 154.94 137.16))
     (stroke (width 0) (type solid))
+  )
+  (wire (pts (xy 147.32 171.45) (xy 147.32 173.99))
+    (stroke (width 0) (type default))
   )
   (wire (pts (xy 78.74 55.88) (xy 78.74 58.42))
@@
     )
   )
+  (symbol (lib_id "Device:C") (at 157.48 167.64 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no)
+    (property "Reference" "C32" (at 162.56 166.37 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Value" "1uF" (at 162.56 168.91 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Footprint" "Capacitor_SMD:C_0402_1005Metric" (at 158.4452 171.45 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (at 157.48 167.64 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (pin "2")
+    (instances
+      (project "pcb"
+        (path "/ba41827b-f176-424d-b6d5-0b0e1ddda097/00000000-0000-0000-0000-00005d4c99f9"
+          (reference "C32") (unit 1)
+        )
+        (path "/ba41827b-f176-424d-b6d5-0b0e1ddda097/a00c2049-0a3f-4994-b4b1-e2d67645b8de"
+          (reference "C512") (unit 1)
+        )
+      )
+    )
+  )
   (symbol (lib_id "power:GND") (at 238.76 144.78 90) (unit 1)
     (in_bom yes) (on_board yes) (dnp no)
@@
         (path "/ba41827b-f176-424d-b6d5-0b0e1ddda097/a00c2049-0a3f-4994-b4b1-e2d67645b8de"
           (reference "#PWR01258") (unit 1)
+        )
+      )
+    )
+  )
+  (symbol (lib_id "Sitina:+2V") (at 137.16 161.29 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no)
+    (property "Reference" "#PWR0205" (at 137.16 165.1 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "+2V" (at 134.62 157.48 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "" (at 137.16 161.29 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (at 137.16 161.29 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (instances
+      (project "pcb"
+        (path "/ba41827b-f176-424d-b6d5-0b0e1ddda097/00000000-0000-0000-0000-00005d4c99f9"
+          (reference "#PWR0205") (unit 1)
+        )
+        (path "/ba41827b-f176-424d-b6d5-0b0e1ddda097/a00c2049-0a3f-4994-b4b1-e2d67645b8de"
+          (reference "#PWR0523") (unit 1)
         )
       )
@@
     )
   )
+  (symbol (lib_id "power:GND") (at 147.32 173.99 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no)
+    (property "Reference" "#PWR0524" (at 147.32 180.34 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "GND" (at 147.447 178.3842 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Footprint" "" (at 147.32 173.99 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (at 147.32 173.99 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (instances
+      (project "pcb"
+        (path "/ba41827b-f176-424d-b6d5-0b0e1ddda097/a00c2049-0a3f-4994-b4b1-e2d67645b8de"
+          (reference "#PWR0524") (unit 1)
+        )
+      )
+    )
+  )
   (symbol (lib_id "Device:LED") (at 256.54 43.18 180) (unit 1)
     (in_bom yes) (on_board yes) (dnp no)
@@
         (path "/ba41827b-f176-424d-b6d5-0b0e1ddda097/a00c2049-0a3f-4994-b4b1-e2d67645b8de"
           (reference "D1207") (unit 1)
+        )
+      )
+    )
+  )
+  (symbol (lib_id "Regulator_Linear:XC6206PxxxMR") (at 147.32 163.83 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "U503" (at 147.32 157.48 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Value" "XC6206P152MR" (at 147.32 160.02 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Footprint" "Package_TO_SOT_SMD:SOT-23-3" (at 147.32 158.115 0)
+      (effects (font (size 1.27 1.27) italic) hide)
+    )
+    (property "Datasheet" "https://www.torexsemi.com/file/xc6206/XC6206.pdf" (at 147.32 163.83 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (pin "2")
+    (pin "3")
+    (instances
+      (project "pcb"
+        (path "/ba41827b-f176-424d-b6d5-0b0e1ddda097/a00c2049-0a3f-4994-b4b1-e2d67645b8de"
+          (reference "U503") (unit 1)
         )
       )
@@
     )
   )
+  (symbol (lib_id "Device:C") (at 137.16 167.64 0) (mirror y) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no)
+    (property "Reference" "C32" (at 132.08 166.37 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Value" "1uF" (at 132.08 168.91 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Footprint" "Capacitor_SMD:C_0402_1005Metric" (at 136.1948 171.45 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (at 137.16 167.64 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (pin "2")
+    (instances
+      (project "pcb"
+        (path "/ba41827b-f176-424d-b6d5-0b0e1ddda097/00000000-0000-0000-0000-00005d4c99f9"
+          (reference "C32") (unit 1)
+        )
+        (path "/ba41827b-f176-424d-b6d5-0b0e1ddda097/a00c2049-0a3f-4994-b4b1-e2d67645b8de"
+          (reference "C513") (unit 1)
+        )
+      )
+    )
+  )
   (symbol (lib_id "power:GND") (at 212.09 55.88 0) (mirror x) (unit 1)
     (in_bom yes) (on_board yes) (dnp no)
@@
         )
       )
+    )
+  )
+  (symbol (lib_id "power:+1V5") (at 157.48 161.29 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no)
+    (property "Reference" "#PWR0207" (at 157.48 165.1 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "+1V5" (at 154.94 157.48 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "" (at 157.48 161.29 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (at 157.48 161.29 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (instances
+      (project "pcb"
+        (path "/ba41827b-f176-424d-b6d5-0b0e1ddda097/00000000-0000-0000-0000-00005d4c99f9"
+          (reference "#PWR0207") (unit 1)
+        )
+        (path "/ba41827b-f176-424d-b6d5-0b0e1ddda097/a00c2049-0a3f-4994-b4b1-e2d67645b8de"
+          (reference "#PWR0522") (unit 1)
+        )
+      )
