# Repository CameraNexus/sitina1 (continued)

## KiCad design Hardware/sensorboard/pcb.kicad_pcb

Board: 4 copper layers, 71.5 x 63.0 mm, 357 parts (90 on the bottom side), 263 nets.

Parts:
C1, C6, C7, C8, C17, C18, C19, C20, C104, C105, C106: 1uF; C_0402_1005Metric
C2, C3: 10uF; C_0805_2012Metric
C4, C5, C43, C44: 4.7uF; C_0402_1005Metric
C9, C10, C45, C52: 22uF 25V; C_0805_2012Metric
C11, C12, C13, C14, C15, C16, C21, C22, C24, C26, C27, C28, C31, C32, C33, C34, C36, C38, C40, C42, C46, C47, C48, C49, C50, C51, C56, C57, C58, C59, C60, C61, C62, C63, C65, C66, C67, C68, C69, C70, C71, C72, C73, C74, C75, C76, C83, C84, C85, C86, C87, C88, C89, C90, C101, C102, C103, C135, C141, C153, C154: 100nF; C_0402_1005Metric
C23, C25, C29, C30, C35, C37, C39, C41, C91, C92, C93, C94, C107, C108, C109: 10uF; C_0603_1608Metric
C53, C54: 220uF / 6V; CP_EIA-3528-15_AVX-H
C55: DNP/1nF; C_0402_1005Metric
C64: 1uF 25V; C_0603_1608Metric
C77, C79: DNP; C_0402_1005Metric
C78, C80, C81, C82: 470uF; C_Elec_6.3x7.7
C95, C96, C97, C98, C99, C100: 1nF; C_0402_1005Metric
C110, C113, C115, C116, C117, C118, C119, C120, C125, C126, C127, C136, C138, C142, C145, C155, C156, C158, C159, C161, C162: 470nF; C_0402_1005Metric
C111, C121, C122, C128, C129, C130, C148, C152, C157, C160, C163: 4.7uF; C_0603_1608Metric
C112, C123, C124, C131, C132, C133: 100uF; C_0805_2012Metric
C114, C151: 47uF; C_0805_2012Metric
C134, C137, C139, C140, C143, C144, C146, C147, C150: 220nF; C_0402_1005Metric
C149: 22uF; C_0603_1608Metric
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10: LED; D_0603_1608Metric
D11, D12, D13, D18, D19, D20: BAT54S; SOT-23
D14, D15, D16, D17: B0540W; D_SOD-323
D21, D22: LED; LED_0603_1608Metric
FB1, FB2, FB3, FB4, FB5, FB6, FB7, FB8, FB9, FB10: FerriteBead; L_0603_1608Metric
FB11: 120R; R_0402_1005Metric
H1, H2, H3: MountingHole; MountingHole_2.2mm_M2_DIN965
HS1: Heatsink; sb_heatsink
J1, J2: FPC 0.5mm Bottom Contact; Hirose_FH12-30S-0.5SH_1x30-1MP_P0.50mm_Horizontal
Q1: BC847BPN; SOT-363_SC-70-6
R1, R2: 249R; R_0402_1005Metric
R3, R4: 30.1K; R_0402_1005Metric
R5, R7, R31: 270K 1%; R_0402_1005Metric
R6, R8, R32: 22K 1%; R_0402_1005Metric
R9, R10, R11, R24, R55, R57, R58, R60, R112: 10K; R_0402_1005Metric
R12, R13, R14, R15, R75, R76, R77, R78, R81, R82, R83, R84, R85, R86, R87, R88: 5.1K; R_0402_1005Metric
R16, R17: 3.3K; R_0402_1005Metric
R18: 500; R_0402_1005Metric
R19, R20: 49.9K 1%; R_0402_1005Metric
R21, R22: 200K 1%; R_0402_1005Metric
R23, R28: 49.9; R_0402_1005Metric
R25, R26, R27, R29, R53, R59: 0; R_0402_1005Metric
R30, R56: 82K 1%; R_0402_1005Metric
R33, R54, R96, R97, R98, R99, R100: 20K; R_0402_1005Metric
R34: 7.5; R_0402_1005Metric
R35, R38, R39, R42, R43, R46: 60R; R_0402_1005Metric
R36, R37, R40, R41, R44, R45: 150R; R_0402_1005Metric
R47, R48, R49, R50, R51, R52: 120R; R_0402_1005Metric
R61, R62, R63, R64, R65, R66, R67, R68, R69, R70, R71, R72: 0.1; R_0603_1608Metric
R73, R74, R79, R80: 22; R_0402_1005Metric
R89: 0; R_0603_1608Metric
R90, R91, R92, R93, R94, R95: 220; R_0402_1005Metric
R101, R103: 1K; R_0402_1005Metric
R102: 4.7K; R_0402_1005Metric
R104: 100K; R_0402_1005Metric
R105: 33R; R_0402_1005Metric
R106: 100R; R_0402_1005Metric
R107, R108: 80R; R_0402_1005Metric
R109, R110: 1.5K/0.5%; R_0402_1005Metric
R111: 240R 1%; R_0402_1005Metric
RN1, RN2, RN3, RN4: 49.9; R_Array_Convex_4x0402
RV1, RV5, RV6, RV7, RV8: 10K; Potentiometer_Bourns_TC33X_Vertical
RV2, RV3, RV4: 50K; Potentiometer_Bourns_TC33X_Vertical
U1, U12: XC6206P152MR; SOT-23-3
U2, U3: LT3045xMSE; MSOP-12-1EP_3x4mm_P0.65mm_EP1.65x2.85mm
U4: XC6206P302MR; SOT-23-3
U5, U6: ADA4800; DFN-6-1EP_1.6x1.6mm_P0.5mm_EP0.5x1.05mm
U7: AD9990; BGA-112_11x11_8.0x8.0mm
U8, U11: TPS72301; SOT-23-5_HandSoldering
U9: TMP1075DGK; VSSOP-8_3.0x3.0mm_P0.65mm
U10: KAI-1100x; KAI-1100X
U13: TLV76701DRVx; WSON-6-1EP_2x2mm_P0.65mm_EP1x1.6mm_ThermalVias
U14, U15, U16, U17, U18, U19: 74HC2G17; SC-74-6_1.5x2.9mm_P0.95mm
U20, U21, U22, U23: 1EDN7550B; SOT-23-6_Handsoldering
U24, U25, U26: IRF9389/7309; SOIC-8_3.9x4.9mm_P1.27mm
U27: XC7Z010-CLG400; Xilinx_CLG400
U28: W25Q128JVP; WSON-8-1EP_4x4mm_P0.8mm_EP1.98x3mm
U29: MT41K256M16HA; BGA-96_9.0x13.0mm_Layout2x3x16_P0.8mm
X1: 33.33MHz; Oscillator_SMD_Abracon_ASE-4Pin_3.2x2.5mm

Connections:
+1V0: C115.1, C116.1, C117.1, C119.1, C121.1, C122.1, C123.1, C124.1, C125.1, C128.1, C131.1, U27.G7 (VCCPINT[6]), U27.G11 (VCCBRAM[2]), U27.G13 (VCCINT[9]), U27.H10 (VCCBRAM[2]), U27.H12 (VCCINT[9]), U27.J7 (VCCPINT[6]), U27.J13 (VCCINT[9]), U27.K12 (VCCINT[9]), U27.L7 (VCCPINT[6]), U27.L13 (VCCINT[9]), U27.M12 (VCCINT[9]), U27.N7 (VCCPINT[6]), U27.N13 (VCCINT[9]), U27.P8 (VCCPINT[6]), U27.P12 (VCCINT[9]), U27.R7 (VCCPINT[6]), U27.R13 (VCCINT[9])
+1V5: C65.1, D12.2 (K), RV3.1, U12.2 (VO), U14.5 (VCC)
+1V8: C6.1, C27.2, C126.1, C127.1, C129.1, C130.1, C132.1, C133.1, C155.1, C156.1, C157.1, FB1.2, FB11.2, J2.30, U1.2 (VO), U7.H5 (DVDD), U27.F8 (VCCPAUX[5]), U27.F11 (VCCBATT_0), U27.G9 (VCCPAUX[5]), U27.H8 (VCCPAUX[5]), U27.J9 (VCCADC_0), U27.J11 (VCCAUX[6]), U27.K8 (VCCPAUX[5]), U27.L11 (VCCAUX[6]), U27.M8 (VCCPAUX[5]), U27.N9 (VCCAUX[6]), U27.N11 (VCCAUX[6]), U27.N19 (VCCO_34[6]), U27.P10 (VCCAUX[6]), U27.R9 (VCCAUX[6]), U27.R15 (VCCO_34[6]), U27.T18 (VCCO_34[6]), U27.V14 (VCCO_34[6]), U27.W17 (VCCO_34[6]), U27.Y20 (VCCO_34[6])
+1V35: C134.1, C136.1, C137.1, C138.1, C139.1, C140.1, C142.1, C143.1, C144.1, C145.1, C146.1, C147.1, C148.1, C149.1, C150.1, C151.1, C152.1, C153.1, J2.27, J2.28, R108.1, R109.1, U27.A3 (VCCO_DDR_502[10]), U27.D2 (VCCO_DDR_502[10]), U27.E5 (VCCO_DDR_502[10]), U27.G1 (VCCO_DDR_502[10]), U27.H4 (VCCO_DDR_502[10]), U27.L3 (VCCO_DDR_502[10]), U27.P2 (VCCO_DDR_502[10]), U27.R5 (VCCO_DDR_502[10]), U27.U1 (VCCO_DDR_502[10]), U27.V4 (VCCO_DDR_502[10]), U29.A1 (VDDQ), U29.A8 (VDDQ), U29.B2 (VDD), U29.C1 (VDDQ), U29.C9 (VDDQ), U29.D2 (VDDQ), U29.D9 (VDD), U29.E9 (VDDQ), U29.F1 (VDDQ), U29.G7 (VDD), U29.H2 (VDDQ), U29.H9 (VDDQ), U29.K2 (VDD), U29.K8 (VDD), U29.N1 (VDD), U29.N9 (VDD), U29.R1 (VDD), U29.R9 (VDD)
+2V: C53.1, C66.1, C67.1, C68.1, C69.1, C70.1, D11.2 (K), D13.2 (K), J1.3, RV2.1, RV4.1, U12.3 (VI), U15.5 (VCC), U16.5 (VCC), U17.5 (VCC), U18.5 (VCC), U19.5 (VCC)
+3V0: C8.1, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C77.2, FB2.1, FB3.1, FB4.1, R18.2, R85.2, R87.2, U4.2 (VO), U7.C2 (RGVDD_A), U7.C10 (RGVDD_B), U7.D3 (HVDD_A), U7.D9 (HVDD_B), U7.E4 (XVVDD), U7.J10 (DRVDD), U7.J11 (IOVDD)
+3V3: C110.2, C111.2, C112.2, C118.2, C120.2, C158.1, C159.1, C160.1, C161.1, C162.1, C163.1, J2.24, J2.25, R96.1, R101.1, R102.1, R104.1, R112.1, U9.8 (V+), U27.A13 (VCCO_MIO1_501[4]), U27.B6 (VCCO_MIO0_500[2]), U27.B16 (VCCO_MIO1_501[4]), U27.C19 (VCCO_35[6]), U27.D7 (VCCO_MIO0_500[2]), U27.D12 (VCCO_MIO1_501[4]), U27.E15 (VCCO_MIO1_501[4]), U27.F18 (VCCO_35[6]), U27.H14 (VCCO_35[6]), U27.J17 (VCCO_35[6]), U27.K6 (VCCO_0), U27.K20 (VCCO_35[6]), U27.M6 (CFGBVS_0), U27.M16 (VCCO_35[6]), U27.N6 (RSVDVCC3), U27.R6 (RSVDVCC2), U27.T6 (RSVDVCC1), U27.T8 (VCCO_13[4]), U27.U11 (VCCO_13[4]), U27.W7 (VCCO_13[4]), U27.Y10 (VCCO_13[4]), U28.8 (VCC), X1.1 (EN), X1.4 (Vdd)
+3V3A: C1.1, C7.1, J1.15, U1.3 (VI), U4.3 (VI)
+5V: C82.1, C90.2, C94.2, J1.28, J1.29, R16.2, U23.4 (VDD)
+8V: C81.1, C87.2, C91.2, C101.2, C104.2, C107.2, J1.19, J1.20, J1.21, R14.2, U20.4 (VDD), U24.3 (SP)
+15VL: C9.1, C16.1, C42.1, FB10.1, R5.1, R20.1, R22.1, R30.1, U2.10 (OUTS), U2.11 (OUT), U2.12 (OUT), U6.5 (VCC)
+15VR: C10.1, C15.1, FB5.1, R7.1, R19.1, R21.1, U3.10 (OUTS), U3.11 (OUT), U3.12 (OUT), U5.5 (VCC)
+16V: C2.1, C3.1, J1.13, J1.14, R9.2, U2.1 (IN), U2.2 (IN), U2.3 (IN), U2.4 (EN/UV), U3.1 (IN), U3.2 (IN), U3.3 (IN), U3.4 (EN/UV)
+16VD: C62.2, J1.5, Q1.4 (E2), R10.2, R57.1, U13.4 (EN), U13.6 (IN)
+DRAM_VREF: C135.1, C141.1, C153.2, C154.1, R109.2, R110.1, U27.H6 (PS_DDR_VREF0_502), U27.P6 (PS_DDR_VREF1_502), U29.H1 (VrefDQ), U29.M8 (VrefCA)
+VAB: C55.2, C56.2, D15.2 (A), R15.2, R56.1, U13.1 (OUT)
-3V5: C76.2, D12.1 (A), R54.1, RV3.3, U11.5 (OUT), U14.2 (GND)
-4V: C54.2, C71.2, C72.2, C73.2, C74.2, C75.2, C79.1, C83.1, C84.1, D11.1 (A), D13.1 (A), J1.7, J1.8, J1.27, R17.2, R53.1, R82.1, R84.1, RV2.3, RV4.3, U11.2 (IN), U15.2 (GND), U16.2 (GND), U17.2 (GND), U18.2 (GND), U19.2 (GND)
-9V: C78.2, C80.2, C88.1, C89.1, C90.1, C92.1, C93.1, C94.1, C102.2, C103.2, C105.1, C106.1, C108.1, C109.1, J1.22, J1.23, J1.24, R12.2, R77.1, R78.1, U21.2 (GND), U22.2 (GND), U23.2 (GND), U25.1 (SN), U26.1 (SN)
-9VA: J1.12, R13.2, R29.1, R34.1, U8.2 (IN)
-15V: C63.1, D14.2 (A), J1.1, R11.2, R59.2
/afe/AVDDA: C23.2, C24.2, U7.A1 (LDOOUT_A), U7.C4 (AVDD_A)
/afe/AVDDB: C25.2, C26.2, U7.A11 (LDOOUT_B), U7.C8 (AVDD_B)
/afe/AVSS: C36.2, C37.2, R27.1, U7.B3 (LDOVSS_A), U7.B9 (LDOVSS_B)
/afe/AVSSA: C11.2, C13.2, C15.2, C17.2, C18.2, C23.1, C24.1, C38.2, C39.2, R25.1, U5.2 (VEE), U5.7 (EPAD), U7.A3 (AVSS_A), U7.A5 (AVSS_A), U7.C5 (AVSS_A)
/afe/AVSSB: C12.2, C14.2, C16.2, C19.2, C20.2, C25.1, C26.1, C40.2, C41.2, R26.1, U6.2 (VEE), U6.7 (EPAD), U7.A7 (AVSS_B), U7.A9 (AVSS_B), U7.C7 (AVSS_B)
/afe/CLI: R23.2, U7.B5 (CLI)
/afe/CSI_D2_pre: RN1.8 (R1.2), U7.H6 (D0)
/afe/CSI_D3_pre: RN1.7 (R2.2), U7.J6 (D1)
/afe/CSI_D4_pre: RN1.5 (R4.2), U7.K6 (D2)
/afe/CSI_D5_pre: RN2.8 (R1.2), U7.L6 (D3)
/afe/CSI_D6_pre: RN2.6 (R3.2), U7.L7 (D4)
/afe/CSI_D7_pre: RN2.5 (R4.2), U7.K7 (D5)
/afe/CSI_D8_pre: RN1.6 (R3.2), U7.J7 (D6)
/afe/CSI_D9_pre: R28.1, U7.H7 (D7)
/afe/CSI_D10_pre: RN3.8 (R1.2), U7.L8 (D8)
/afe/CSI_D11_pre: RN3.7 (R2.2), U7.K8 (D9)
/afe/CSI_D12_pre: RN2.7 (R2.2), U7.J8 (D10)
/afe/CSI_D13_pre: RN3.6 (R3.2), U7.L9 (D11)
/afe/CSI_D14_pre: RN3.5 (R4.2), U7.K9 (D12)
/afe/CSI_D15_pre: RN4.7 (R2.2), U7.K10 (D13)
/afe/CSI_DCLK_pre: RN4.8 (R1.2), U7.L10 (DCLK)
/afe/CSI_HD_pre: RN4.5 (R4.2), U7.H11 (HD)
/afe/CSI_VD_pre: RN4.6 (R3.2), U7.H10 (VD)
/ccd/VDDL: C51.1, C52.1, FB10.2, U10.18 (VDDR)
/ccd/VDDR: C45.1, C48.1, FB5.2, U10.3 (VDDL)
/ccd/VOD: C44.2, FB6.1, FB7.1, R32.1, U8.5 (OUT)
/ccd/VOGL: C49.1, FB7.2, U10.40 (OGL)
/ccd/VOGR: C50.1, FB6.2, U10.21 (OGR)
/ccd/VRDL: C46.1, FB9.2, U10.38 (VRDL)
/ccd/VRDR: C47.1, FB8.2, U10.23 (VRDR)
/ccd_driver/H1BINL: R64.1, U15.4 (2Y)
/ccd_driver/H1BINR: R63.1, U15.6 (1Y)
/ccd_driver/H1BL: R68.1, U17.4 (2Y)
/ccd_driver/H1BR: R69.1, U18.6 (1Y)
/ccd_driver/H1S: C58.2, D13.3 (COM), RV4.2, U15.1 (1A), U15.3 (2A), U16.1 (1A), U17.3 (2A), U18.1 (1A), U19.3 (2A)
/ccd_driver/H1SL: R65.1, U16.6 (1Y)
/ccd_driver/H1SR: R72.1, U19.4 (2Y)
/ccd_driver/H2BL: R67.1, U17.6 (1Y)
/ccd_driver/H2BR: R70.1, U18.4 (2Y)
/ccd_driver/H2S: C59.2, D11.3 (COM), RV2.2, U16.3 (2A), U17.1 (1A), U18.3 (2A), U19.1 (1A)
/ccd_driver/H2SL: R66.1, U16.4 (2Y)
/ccd_driver/H2SR: R71.1, U19.6 (1Y)
/ccd_driver/RGS: C57.2, D12.3 (COM), RV3.2, U14.1 (1A), U14.3 (2A)
/ccd_driver/RL: R62.1, U14.4 (2Y)
/ccd_driver/RR: R61.1, U14.6 (1Y)
/ccd_driver_v/V1S: D20.3 (COM), R94.1, R95.2, U22.5 (OUT_SRC), U22.6 (OUT_SNK)
/ccd_driver_v/V2S: D19.3 (COM), R92.1, R93.2, U21.5 (OUT_SRC), U21.6 (OUT_SNK)
/ccd_driver_v/V23: D18.3 (COM), R90.1, R91.2, U20.5 (OUT_SRC), U20.6 (OUT_SNK)
/fpga_config/FPGA_DONE: D21.2 (A), R101.2, U27.R11 (DONE_0)
/fpga_config/FPGA_INIT_B: R102.2, U27.R10 (INIT_B_0)
/fpga_config/PS_CLK: R105.2, U27.E7 (PS_CLK_500)
/fpga_config/VCCPLL: C113.2, C114.2, FB11.1, U27.G8 (VCCPLL)
/fpga_ddr/DRAM_ADDR0: U27.N2 (PS_DDR_A0_502), U29.N3 (A0)
/fpga_ddr/DRAM_ADDR1: U27.K2 (PS_DDR_A1_502), U29.P7 (A1)
/fpga_ddr/DRAM_ADDR2: U27.M3 (PS_DDR_A2_502), U29.P3 (A2)
/fpga_ddr/DRAM_ADDR3: U27.K3 (PS_DDR_A3_502), U29.N2 (A3)
/fpga_ddr/DRAM_ADDR4: U27.M4 (PS_DDR_A4_502), U29.P8 (A4)
/fpga_ddr/DRAM_ADDR5: U27.L1 (PS_DDR_A5_502), U29.P2 (A5)
/fpga_ddr/DRAM_ADDR6: U27.L4 (PS_DDR_A6_502), U29.R8 (A6)
/fpga_ddr/DRAM_ADDR7: U27.K4 (PS_DDR_A7_502), U29.R2 (A7)
/fpga_ddr/DRAM_ADDR8: U27.K1 (PS_DDR_A8_502), U29.T8 (A8)
/fpga_ddr/DRAM_ADDR9: U27.J4 (PS_DDR_A9_502), U29.R3 (A9)
/fpga_ddr/DRAM_ADDR10: U27.F5 (PS_DDR_A10_502), U29.L7 (A10)
/fpga_ddr/DRAM_ADDR11: U27.G4 (PS_DDR_A11_502), U29.R7 (A11)
/fpga_ddr/DRAM_ADDR12: U27.E4 (PS_DDR_A12_502), U29.N7 (A12/~BC)
/fpga_ddr/DRAM_ADDR13: U27.D4 (PS_DDR_A13_502), U29.T3 (A13)
/fpga_ddr/DRAM_ADDR14: U27.F4 (PS_DDR_A14_502), U29.T7 (A14/NC)
/fpga_ddr/DRAM_BA0: U27.L5 (PS_DDR_BA0_502), U29.M2 (BA0)
/fpga_ddr/DRAM_BA1: U27.R4 (PS_DDR_BA1_502), U29.N8 (BA1)
/fpga_ddr/DRAM_BA2: U27.J5 (PS_DDR_BA2_502), U29.M3 (BA2)
/fpga_ddr/DRAM_CASB: U27.P5 (PS_DDR_CAS_B_502), U29.K3 (~CAS)
/fpga_ddr/DRAM_CKE: U27.N3 (PS_DDR_CKE_502), U29.K9 (CKE)
/fpga_ddr/DRAM_CKN: R106.2, U27.M2 (PS_DDR_CKN_502), U29.K7 (~CK)
/fpga_ddr/DRAM_CKP: R106.1, U27.L2 (PS_DDR_CKP_502), U29.J7 (CK)
/fpga_ddr/DRAM_CSB: U27.N1 (PS_DDR_CS_B_502), U29.L2 (~CS)
/fpga_ddr/DRAM_DATA0: U27.C3 (PS_DDR_DQ0_502), U29.H8 (DQ5)
/fpga_ddr/DRAM_DATA1: U27.B3 (PS_DDR_DQ1_502), U29.F2 (DQ2)
/fpga_ddr/DRAM_DATA2: U27.A2 (PS_DDR_DQ2_502), U29.G2 (DQ6)
/fpga_ddr/DRAM_DATA3: U27.A4 (PS_DDR_DQ3_502), U29.H3 (DQ4)
/fpga_ddr/DRAM_DATA4: U27.D3 (PS_DDR_DQ4_502), U29.F7 (DQ1)
/fpga_ddr/DRAM_DATA5: U27.D1 (PS_DDR_DQ5_502), U29.E3 (DQ0)
/fpga_ddr/DRAM_DATA6: U27.C1 (PS_DDR_DQ6_502), U29.H7 (DQ7)
/fpga_ddr/DRAM_DATA7: U27.E1 (PS_DDR_DQ7_502), U29.F8 (DQ3)
/fpga_ddr/DRAM_DATA8: U27.E2 (PS_DDR_DQ8_502), U29.C2 (DQ11)
/fpga_ddr/DRAM_DATA9: U27.E3 (PS_DDR_DQ9_502), U29.A2 (DQ13)
/fpga_ddr/DRAM_DATA10: U27.G3 (PS_DDR_DQ10_502), U29.A3 (DQ15)
/fpga_ddr/DRAM_DATA11: U27.H3 (PS_DDR_DQ11_502), U29.C3 (DQ9)
/fpga_ddr/DRAM_DATA12: U27.J3 (PS_DDR_DQ12_502), U29.A7 (DQ12)
/fpga_ddr/DRAM_DATA13: U27.H2 (PS_DDR_DQ13_502), U29.D7 (DQ8)
/fpga_ddr/DRAM_DATA14: U27.H1 (PS_DDR_DQ14_502), U29.B8 (DQ14)
/fpga_ddr/DRAM_DATA15: U27.J1 (PS_DDR_DQ15_502), U29.C8 (DQ10)
/fpga_ddr/DRAM_DQM0: U27.A1 (PS_DDR_DM0_502), U29.E7 (LDM)
/fpga_ddr/DRAM_DQM1: U27.F1 (PS_DDR_DM1_502), U29.D3 (UDM)
/fpga_ddr/DRAM_ODT: U27.N5 (PS_DDR_ODT_502), U29.K1 (ODT)
/fpga_ddr/DRAM_RASB: U27.P4 (PS_DDR_RAS_B_502), U29.J3 (~RAS)
/fpga_ddr/DRAM_RST: U27.B4 (PS_DDR_DRST_B_502), U29.T2 (~RESET)
/fpga_ddr/DRAM_SDQSN_0: U27.B2 (PS_DDR_DQS_N0_502), U29.G3 (~LDQS)
/fpga_ddr/DRAM_SDQSN_1: U27.F2 (PS_DDR_DQS_N1_502), U29.B7 (~UDQS)
/fpga_ddr/DRAM_SDQSP_0: U27.C2 (PS_DDR_DQS_P0_502), U29.F3 (LDQS)
/fpga_ddr/DRAM_SDQSP_1: U27.G2 (PS_DDR_DQS_P1_502), U29.C7 (UDQS)
/fpga_ddr/DRAM_WEB: U27.M5 (PS_DDR_WE_B_502), U29.L3 (~WE)
/fpga_io/PS_SRST_B: R112.2, U27.B10 (PS_SRST_B_501)
AFE_FDG: R80.1, U7.G4 (XV4)
AFE_H1: C58.1, U7.E1 (H1A)
AFE_H2: C59.1, U7.E2 (H2A)
AFE_RG: C57.1, U7.C1 (HL_A)
AFE_RST: U7.H8 (RSTB), U27.B20 (IO_L1N_T0_AD0N_35)
AFE_SCK: U7.E8 (SCK), U27.D18 (IO_L3N_T0_DQS_AD1N_35)
AFE_SDATA: U7.E9 (SDATA), U27.C20 (IO_L1P_T0_AD0P_35)
AFE_SL: U7.D7 (SL), U27.D19 (IO_L4P_T0_35)
AFE_STROBE: C60.2, C61.2, U7.G11 (GPO1)
AFE_V1: R74.1, U7.F3 (XV1)
AFE_V2: R73.1, U7.F2 (XV2)
AFE_V23: R79.1, U7.F1 (XV3)
CCDIN_L: U6.1 (IN), U10.19 (VOUTR)
CCDIN_R: U5.1 (IN), U10.2 (VOUTL)
CSI_D2: RN1.1 (R1.1), U27.K19 (IO_L10P_T1_AD11P_35)
CSI_D3: RN1.2 (R2.1), U27.J19 (IO_L10N_T1_AD11N_35)
CSI_D4: RN1.4 (R4.1), U27.J20 (IO_L17P_T2_AD5P_35)
CSI_D5: RN2.1 (R1.1), U27.H18 (IO_L14N_T2_AD4N_SRCC_35)
CSI_D6: RN2.3 (R3.1), U27.H20 (IO_L17N_T2_AD5N_35)
CSI_D7: RN2.4 (R4.1), U27.G19 (IO_L18P_T2_AD13P_35)
CSI_D8: RN1.3 (R3.1), U27.G20 (IO_L18N_T2_AD13N_35)
CSI_D9: R28.2, U27.F19 (IO_L15P_T2_DQS_AD12P_35)
CSI_D10: RN3.1 (R1.1), U27.F20 (IO_L15N_T2_DQS_AD12N_35)
CSI_D11: RN3.2 (R2.1), U27.E19 (IO_L5N_T0_AD9N_35)
CSI_D12: RN2.2 (R2.1), U27.E18 (IO_L5P_T0_AD9P_35)
CSI_D13: RN3.3 (R3.1), U27.D20 (IO_L4N_T0_35)
CSI_HSYNC: RN4.4 (R4.1), U27.M19 (IO_L7P_T1_AD2P_35)
CSI_PIXCLK: RN4.1 (R1.1), U27.M18 (IO_L8N_T1_AD10N_35)
CSI_VSYNC: RN4.3 (R3.1), U27.M20 (IO_L7N_T1_AD2N_35)
DSI_HS_CKN: R37.2, U27.U20 (IO_L15N_T2_DQS_34)
DSI_HS_CKP: R36.2, U27.T20 (IO_L15P_T2_DQS_34)
DSI_HS_D0N: R41.2, U27.Y18 (IO_L17P_T2_34)
DSI_HS_D0P: R40.2, U27.Y19 (IO_L17N_T2_34)
DSI_LP_CKN: R38.2, U27.V20 (IO_L16P_T2_34)
DSI_LP_CKP: R35.2, U27.R18 (IO_L20N_T3_34)
DSI_LP_D0N: R42.2, U27.Y17 (IO_L7N_T1_34)
DSI_LP_D0P: R39.2, U27.W19 (IO_L22N_T3_34)
FDG_CCD: R89.1, U10.22 (FD), U10.39 (FD)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, C34.1, C35.1, C42.2, C43.2, C44.1, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, C53.2, C54.1, C56.1, C62.1, C63.2, C65.2, C66.2, C67.2, C68.2, C69.2, C70.2, C71.1, C72.1, C73.1, C74.1, C75.1, C76.1, C77.1, C78.1, C79.2, C80.1, C81.2, C82.2, C85.1, C86.1, C87.1, C88.2, C89.2, C91.1, C92.2, C93.2, C101.1, C102.1, C103.1, C104.1, C105.2, C106.2, C107.1, C108.2, C109.2, C110.1, C111.1, C112.1, C113.1, C114.1, C115.2, C116.2, C117.2, C118.1, C119.2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
H1BINL_CCD: R64.2, U10.5 (H1BINL)
H1BINR_CCD: R63.2, U10.16 (H1BINR)
H1BL_CCD: R68.2, U10.9 (H1BL)
H1BR_CCD: R69.2, U10.12 (H1BR)
H1SL_CCD: R65.2, U10.8 (H1SL)
H1SR_CCD: R72.2, U10.13 (H1SR)
H2BL_CCD: R67.2, U10.10 (H2BL)
H2BR_CCD: R70.2, U10.11 (H2BR)
H2SL_CCD: R66.2, U10.7 (H2SL)
H2SR_CCD: R71.2, U10.14 (H2SR)
MIPI_CKN: R37.1, R38.1, R48.2
MIPI_CKP: R35.1, R36.1, R47.2
MIPI_D0N: R41.1, R42.1, R45.1, R46.1, R50.2, R52.2
MIPI_D0P: R39.1, R40.1, R43.1, R44.1, R49.2, R51.2
unnamed: C43.1, FB8.1, FB9.1, R30.2, R31.1
unnamed: D1.2 (A), R9.1
unnamed: D2.2 (A), R10.1
unnamed: D3.1 (K), R11.1
unnamed: D4.1 (K), R12.1
unnamed: D5.1 (K), R13.1
unnamed: D6.2 (A), R14.1
unnamed: D7.2 (A), R15.1
unnamed: D8.2 (A), R16.1
unnamed: D9.1 (K), R17.1
unnamed: D10.2 (A), R18.1
unnamed: C61.1, D14.1 (K), Q1.2 (B1), R58.1
unnamed: D16.1 (K), R73.2, R75.1
unnamed: D17.1 (K), R74.2, R76.1
unnamed: C96.1, D18.1 (A), R91.1, U24.2 (GN)
unnamed: C95.2, D18.2 (K), R90.2, U24.4 (GP)
unnamed: C98.1, D19.1 (A), R93.1, U25.2 (GN)
unnamed: C97.2, D19.2 (K), R92.2, U25.4 (GP)
unnamed: C100.1, D20.1 (A), R95.1, U26.2 (GN)
unnamed: C99.2, D20.2 (K), R94.2, U26.4 (GP)
unnamed: D22.2 (A), R103.2
unnamed: C64.2, Q1.3 (C2), Q1.6 (C1)
unnamed: Q1.1 (E1), R59.1
unnamed: C60.1, Q1.5 (B2), R57.2
unnamed: R56.2, RV1.1
unnamed: R81.1, RV5.1
unnamed: R82.2, RV5.3
unnamed: R83.1, RV6.1
unnamed: R84.2, RV6.3
unnamed: R85.1, RV7.1
unnamed: R86.2, RV7.3
unnamed: R87.1, RV8.1
unnamed: R88.2, RV8.3
unnamed: R1.1, U2.6 (ILIM)
unnamed: R5.2, R6.1, U2.7 (PGFB)
unnamed: C4.1, R3.1, U2.8 (SET)
unnamed: R2.1, U3.6 (ILIM)
unnamed: R7.2, R8.1, U3.7 (PGFB)
unnamed: C5.1, R4.1, U3.8 (SET)
unnamed: C13.1, R21.2, U5.4 (IDRV)
unnamed: C11.1, R19.2, U5.6 (ISF)
unnamed: C21.2, U5.3 (OUT)
unnamed: C14.1, R22.2, U6.4 (IDRV)
unnamed: C12.1, R20.2, U6.6 (ISF)
unnamed: C22.2, U6.3 (OUT)
unnamed: C21.1, U7.A2 (CCDIN_A)
unnamed: C22.1, U7.A10 (CCDIN_B)
unnamed: C36.1, C37.1, FB4.2, U7.A6 (CLIVDD)
unnamed: C38.1, C39.1, FB3.2, U7.B2 (LDOIN_A)
unnamed: C40.1, C41.1, FB2.2, U7.B10 (LDOIN_B)
unnamed: C18.1, U7.A4 (REFB_A)
unnamed: C20.1, U7.A8 (REFB_B)
unnamed: C17.1, U7.B4 (REFT_A)
unnamed: C19.1, U7.B8 (REFT_B)
unnamed: R24.2, U7.H9 (SYNC)
unnamed: C28.2, FB1.1, U7.B7 (TCVDD)
unnamed: R29.2, U8.3 (EN)
unnamed: R32.2, R33.1, U8.4 (NR/FB)
unnamed: R34.2, U10.27 (ESD)
unnamed: R53.2, U11.3 (EN)
unnamed: R54.2, R55.1, U11.4 (NR/FB)
unnamed: C55.1, RV1.2, U13.2 (FB)
unnamed: R79.2, U20.3 (IN+)
unnamed: C85.2, RV7.2, U20.1 (IN-)
unnamed: R75.2, R77.2, U21.3 (IN+)
unnamed: C83.2, RV5.2, U21.1 (IN-)
unnamed: R76.2, R78.2, U22.3 (IN+)
unnamed: C84.2, RV6.2, U22.1 (IN-)
unnamed: R80.2, U23.3 (IN+)
unnamed: C86.2, RV8.2, U23.1 (IN-)
unnamed: R89.2, U23.5 (OUT_SRC), U23.6 (OUT_SNK)
unnamed: C95.1, C96.2, U24.5 (DP), U24.6 (DP), U24.7 (DN), U24.8 (DN), U25.3 (SP)
unnamed: R108.2, U27.G5 (PS_DDR_VRN_502)
unnamed: R107.2, U27.H5 (PS_DDR_VRP_502)
unnamed: R111.2, U29.L8 (ZQ)
unnamed: R105.1, X1.3 (OUT)
QSPI_DATA0: R99.2, U27.B8 (PS_MIO2_500), U28.5 (DI(IO0))
QSPI_DATA1: R97.2, U27.D6 (PS_MIO3_500), U28.2 (DO(IO1))
QSPI_DATA2: R98.2, U27.B7 (PS_MIO4_500), U28.3 (IO2)
QSPI_DATA3: R96.2, U27.A6 (PS_MIO5_500), U28.7 (IO3)
QSPI_SCLK: R100.2, U27.A5 (PS_MIO6_500), U28.6 (CLK)
QSPI_SS0: R104.2, U27.A7 (PS_MIO1_500), U28.1 (~CS)
RL_CCD: R62.2, U10.1 (RL)
RR_CCD: R61.2, U10.20 (RR)
V1_CCD: C99.1, C100.2, U10.25 (V1), U10.37 (V1), U26.5 (DP), U26.6 (DP), U26.7 (DN), U26.8 (DN)
V2_CCD: C97.1, C98.2, U10.24 (V2), U10.36 (V2), U25.5 (DP), U25.6 (DP), U25.7 (DN), U25.8 (DN)
VSUB_CCD: C64.1, D15.1 (K), R60.1, U10.34 (SUB)

## KiCad design Hardware/powerboard/PowerBoard.kicad_pcb

Parts:
C1, C6, C27: 22pF; C_0402_1005Metric
C2, C5, C22, C23: 220nF; C_0402_1005Metric
C3, C24: 4.7nF; C_0402_1005Metric
C4, C25: 10nF; C_0402_1005Metric
C7, C28: DNP; C_0402_1005Metric
C8, C29: 22uF 25V; C_0805_2012Metric
C9, C30: 10uF; C_0603_1608Metric
C10, C15, C16, C19, C20, C31, C45, C47: 10uF 25V; C_0805_2012Metric
C11, C14, C26, C48: 2.2uF 25V; C_0603_1608Metric
C12, C13, C43, C44: 47nF; C_0402_1005Metric
C17: 22uF; C_0805_2012Metric
C21, C32: 100nF; C_0402_1005Metric
CT1, CT2, CT3, CT4: 330uF 6.3V; CP_EIA-7343-43_Kemet-X
D1, D2, D3, D4, D5, D6, D17, D18: B0540W; D_SOD-323
H1, H2, H3: MountingHole; MountingHole_2.2mm_M2_DIN965
J1: FPC 0.5mm Bottom Contact; Hirose_FH12-30S-0.5SH_1x30-1MP_P0.50mm_Horizontal
J3: FH-00176; PinSocket_2x04_P2.00mm_Vertical_SMD
L1, L2, L3, L4, L5, L6, L7, L8, L9: 4.7uH; L_1212
R1, R13: 100; R_0402_1005Metric
R2: 82K 1%; R_0402_1005Metric
R3, R17, R18: 270K 1%; R_0402_1005Metric
R4: 68K 1%; R_0402_1005Metric
R5, R19, R20: 22K 1%; R_0402_1005Metric
R6, R7, R35, R36: 12k; R_0402_1005Metric
R8, R9, R10, R32, R33, R34: DNP; R_0402_1005Metric
R11: 158K; R_0402_1005Metric
R12, R39: 133K; R_0402_1005Metric
R14: 1.40M; R_0402_1005Metric
R15, R40: 1.62M; R_0402_1005Metric
R16: 27K 1%; R_0402_1005Metric
R21: 12K 1%; R_0402_1005Metric
R37: 137K; R_0402_1005Metric
R38: 2.43M; R_0402_1005Metric
U1, U6: TPS65130RGE; VQFN-24-1EP_4x4mm_P0.5mm_EP2.45x2.45mm_ThermalVias
U2, U4: ADP5071ACPZ; LFCSP-20-1EP_4x4mm_P0.5mm_EP2.6x2.6mm_ThermalVias
U7: SY8120; TSOT-23-6

Connections:
+SYS: C10.1, C19.1, C20.1, C21.2, C31.1, CT1.1, CT2.1, CT3.1, CT4.1, J3.3, J3.5, J3.7, L1.2, L5.2, R1.2, R13.2, U1.5 (INN), U1.6 (INN), U2.15 (PVIN1), U2.16 (PVINSYS), U2.17 (PVIN2), U4.15 (PVIN1), U4.16 (PVINSYS), U4.17 (PVIN2), U6.5 (INN), U6.6 (INN), U7.5 (IN)
/+2VD: C1.1, C17.1, J1.3, L9.1, R16.1
/+5VD: C6.1, C8.1, D1.1 (K), J1.28, J1.29, R4.1, U1.23 (VPOS)
/+8VD: C16.1, D4.1 (K), J1.19, J1.20, J1.21, R14.2
/+16VA: C45.1, D17.1 (K), J1.13, J1.14, R38.2
/+16VD: C27.1, C29.1, D5.1 (K), J1.5, R18.1, U6.23 (VPOS)
/-4VD: C7.2, C9.1, D2.2 (A), J1.7, J1.8, J1.27, R3.2, U1.15 (VNEG)
/-9VA: C47.1, D18.2 (A), J1.12, R40.2
/-9VD: C15.1, D3.2 (A), J1.22, J1.23, J1.24, R15.2
/-15VD: C28.2, C30.1, D6.2 (A), J1.1, R17.2, U6.15 (VNEG)
CCD_AFE_SYNC: J1.9, U4.2 (SYNC/FREQ)
CCD_POWEREN: J3.1, U1.8 (ENP), U1.10 (ENN), U2.7 (EN1), U2.9 (EN2), U4.7 (EN1), U4.9 (EN2), U6.8 (ENP), U6.10 (ENN), U7.4 (~SHDN)
CCD_PULSE_SYNC: J1.10, U2.2 (SYNC/FREQ)
GND: C2.2, C3.2, C4.2, C5.2, C8.2, C9.2, C10.2, C11.1, C12.1, C13.1, C14.1, C15.2, C16.2, C17.2, C19.2, C20.2, C21.1, C22.2, C23.2, C24.2, C25.2, C26.1, C29.2, C30.2, C31.2, C43.1, C44.1, C45.2, C47.2, C48.1, CT1.2, CT2.2, CT3.2, CT4.2, J1.2, J1.4, J1.6, J1.11, J1.15, J1.16, J1.17, J1.18, J1.25, J1.26, J1.30, J3.2, J3.4, J3.6, J3.8, L2.1, L4.1, L6.1, L8.1, R5.2, R8.2, R9.2, R10.2, R11.2, R19.2, R21.2, R32.2, R33.2, R34.2, R37.2, U1.2 (PGND), U1.3 (PGND), U1.19 (AGND), U1.25 (EP), U2.13 (AGND), U2.19 (PGND), U2.21 (AGND), U4.13 (AGND), U4.19 (PGND), U4.21 (EPAD), U6.2 (PGND), U6.3 (PGND), U6.19 (AGND), U6.25 (EP), U7.2 (GND)
unnamed: C12.2, R6.2
unnamed: C13.2, R7.2
unnamed: C43.2, R35.2
unnamed: C44.2, R36.2
unnamed: D1.2 (A), L1.1, U1.1 (INP), U1.24 (INP)
unnamed: D2.1 (K), L2.2, U1.13 (OUTN), U1.14 (OUTN)
unnamed: D3.1 (K), L4.2, U2.18 (SW2)
unnamed: D4.2 (A), L3.1, U2.20 (SW1)
unnamed: D5.2 (A), L5.1, U6.1 (INP), U6.24 (INP)
unnamed: D6.1 (K), L6.2, U6.13 (OUTN), U6.14 (OUTN)
unnamed: D17.2 (A), L7.1, U4.20 (SW1)
unnamed: D18.1 (K), L8.2, U4.18 (SW2)
unnamed: C3.1, U1.18 (CN)
unnamed: C4.1, U1.21 (CP)
unnamed: C7.1, R2.2, R3.1, U1.16 (FBN)
unnamed: C6.2, R4.2, R5.1, U1.22 (FBP)
unnamed: C2.1, R1.1, U1.4 (VIN), U1.9 (PSP), U1.11 (PSN)
unnamed: C5.1, R2.1, U1.17 (VREF)
unnamed: R6.1, U2.6 (COMP1)
unnamed: R7.1, U2.10 (COMP2)
unnamed: R11.1, R14.1, U2.5 (FB1)
unnamed: R12.1, R15.1, U2.11 (FB2)
unnamed: L3.2, U2.1 (INBK)
unnamed: R10.1, U2.3 (SEQ)
unnamed: R9.1, U2.4 (SLEW)
unnamed: R8.1, U2.8 (SS)
unnamed: C14.2, R12.2, U2.12 (VREF)
unnamed: C11.2, U2.14 (VREG)
unnamed: R36.1, U4.6 (COMP1)
unnamed: R35.1, U4.10 (COMP2)
unnamed: R37.1, R38.1, U4.5 (FB1)
unnamed: R39.1, R40.1, U4.11 (FB2)
unnamed: L7.2, U4.1 (INBK)
unnamed: R34.1, U4.3 (SEQ)
unnamed: R33.1, U4.4 (SLEW)
unnamed: R32.1, U4.8 (SS)
unnamed: C48.2, R39.2, U4.12 (VREF)
unnamed: C26.2, U4.14 (VREG)
unnamed: C24.1, U6.18 (CN)
unnamed: C25.1, U6.21 (CP)
unnamed: C28.1, R17.1, R20.2, U6.16 (FBN)
unnamed: C27.2, R18.2, R19.1, U6.22 (FBP)
unnamed: C22.1, R13.1, U6.4 (VIN), U6.9 (PSP), U6.11 (PSN)
unnamed: C23.1, R20.1, U6.17 (VREF)
unnamed: C32.2, U7.1 (BS)
unnamed: C1.2, R16.2, R21.1, U7.3 (FB)
unnamed: C32.1, L9.2, U7.6 (SW)

Notes on the sheet:
PULSE
NOM:-8.944V
NOM:+7.89V
Panasonic 6TPC330MA
HIGH POWER PULSE
NOM:+14.99V
To Sensor Board
SENSITIVE
Power Diagram

Notes on the sheet:
+VSD
page 7 - U520
page 6 - U509-513
LT3045
PMIC AXP209
LDO2
MT9700
+1V8
IRF9389
Sensor Board
74HC2G17
HIGH POWER PULSE
ILM1.7A
XC6206
OLM0.2A
VCI
PULSE
1EDN7550B
+15VL
page 7 - U518, U519
SNVS
USBC-1
SDRAM
H2BR H1BR
Power Board
LDO4
+3.2~4.2
SENSITIVE
RDIV
ADA4800 PreAmp
OLM0.03A
page 7 - U517
19.2V 40mA
page 7 - U514
Legends
Charge LM 1.8A
+5VP
+VCCIO_SD
+CCDPWR
+3V3_LENS

Board: 2 copper layers, 67.0 x 66.6 mm, 97 parts (1 on the bottom side), 61 nets.
