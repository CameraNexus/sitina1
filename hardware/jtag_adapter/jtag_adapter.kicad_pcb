# Repository CameraNexus/sitina1 (continued)

## KiCad design hardware/ioboard/pcb.kicad_pcb (continued)

Board: 4 copper layers, 71.6 x 73.2 mm, 222 parts (44 on the bottom side), 136 nets.

Other parts of the board:
MICRO_SD1: MICRO_SD(TFC-WPAPR-08); TFC-WPAPR-08
R36, R38: 10K; R_0402_1005Metric
R39, R40: 2.2K; R_0402_1005Metric

Their connections:
+3V3: R36.1, R38.1, R39.1, R40.1; also elsewhere on the board
+VSD: MICRO_SD1.4 (VDD); also elsewhere on the board
GND: MICRO_SD1.6 (VSS), MICRO_SD1.10, MICRO_SD1.11, MICRO_SD1.12, MICRO_SD1.13; also elsewhere on the board
I2C1_SDA: R39.2; also elsewhere on the board
I2C2_SCL: R38.2; also elsewhere on the board
I2C2_SDA: R36.2; also elsewhere on the board
unnamed 78: MICRO_SD1.5 (CLK/SCLK); also elsewhere on the board
SDIO_CMD: MICRO_SD1.3 (CMD/DI); also elsewhere on the board
SDIO_DAT0: MICRO_SD1.7 (DAT0/DO); also elsewhere on the board
SDIO_DAT1: MICRO_SD1.8 (DAT1/RES); also elsewhere on the board
SDIO_DAT2: MICRO_SD1.1 (DAT2/RES); also elsewhere on the board
SDIO_DAT3: MICRO_SD1.2 (CD/DAT3/CS); also elsewhere on the board

## KiCad design hardware/gripflex/gripflex.kicad_pcb

Parts:
C1, C2, C3: 100nF; C_0402_1005Metric
J1: Conn_01x10_MountingPin; Hirose_FH12-10S-0.5SH_1x10-1MP_P0.50mm_Horizontal
J2: Conn_01x12; FPC_12
J3: Conn_01x02_MountingPin; JST_PH_S2B-PH-SM4-TB_1x02-1MP_P2.00mm_Horizontal
RN1, RN2, RN3, RN4: 10K; R_Array_Convex_4x0402
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13: HX-TS5208A
U1: SIQ-02FVS3_L
U2, U3: 74HC165; TSSOP-16_4.4x5mm_P0.65mm

Connections:
+3V3: C1.1, C2.1, C3.1, J1.5, J1.6, J1.7, J2.11, RN1.5 (R4.2), RN1.6 (R3.2), RN1.7 (R2.2), RN1.8 (R1.2), RN2.5 (R4.2), RN2.6 (R3.2), RN2.7 (R2.2), RN2.8 (R1.2), RN3.5 (R4.2), RN3.6 (R3.2), RN3.7 (R2.2), RN3.8 (R1.2), RN4.5 (R4.2), RN4.6 (R3.2), RN4.7 (R2.2), RN4.8 (R1.2), U2.16 (VCC), U3.16 (VCC)
+BATT: J2.8, J2.9, J2.10, J3.1
/ENCA: RN2.3 (R3.1), U1.A, U2.4 (D5)
/ENCB: RN2.2 (R2.1), U1.B, U2.5 (D6)
/ENCS: RN2.1 (R1.1), U1.S, U2.6 (D7)
/KEYAF: RN1.4 (R4.1), SW5.1, U2.11 (D0)
/KEYALT: RN1.2 (R2.1), SW8.1, U2.13 (D2)
/KEYDOWN: RN3.1 (R1.1), SW4.1, U3.14 (D3)
/KEYFN5: RN4.2 (R2.1), SW12.1, U3.5 (D6)
/KEYFN6: RN4.1 (R1.1), SW13.1, U3.6 (D7)
/KEYISO: RN1.3 (R3.1), SW7.1, U2.12 (D1)
/KEYLEFT: RN3.3 (R3.1), SW2.1, U3.12 (D1)
/KEYMENU: RN4.4 (R4.1), SW10.1, U3.3 (D4)
/KEYMODE: RN1.1 (R1.1), SW9.1, U2.14 (D3)
/KEYPB: RN4.3 (R3.1), SW11.1, U3.4 (D5)
/KEYRIGHT: RN3.2 (R2.1), SW3.1, U3.13 (D2)
/KEYSHTR: RN2.4 (R4.1), SW6.1, U2.3 (D4)
/KEYUP: RN3.4 (R4.1), SW1.1, U3.11 (D0)
GND: C1.2, C2.2, C3.2, J1.4, J1.8, J1.9, J1.10, J1.MP (MountPin), J2.5, J2.6, J2.7, J2.12, J3.2, J3.MP (MountPin), SW1.2, SW2.2, SW3.2, SW4.2, SW5.2, SW6.2, SW7.2, SW8.2, SW9.2, SW10.2, SW11.2, SW12.2, SW13.2, U1.C, U2.8 (GND), U2.10 (DS), U2.15 (~CE), U3.8 (GND), U3.15 (~CE)
unnamed: U2.9 (Q7), U3.10 (DS)
SPI_CS: J1.3, J2.3, U2.1 (~PL), U3.1 (~PL)
SPI_MISO: J2.4, U3.9 (Q7)
SPI_MOSI: J1.2, J2.2
SPI_SCLK: J1.1, J2.1, U2.2 (CP), U3.2 (CP)

Board: 2 copper layers, 68.3 x 92.2 mm, 26 parts (4 on the bottom side), 24 nets.

## KiCad design hardware/usbc_breakout/usbc_breakout.kicad_pcb

Parts:
C1: 1uF; C_0603_1608Metric
D1: B0540W; D_SOD-323
J1: USB_C_Receptacle_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J2, J3: Conn_01x01; PinHeader_1x01_P2.54mm_Vertical
J4: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
J5: Conn_02x02_Odd_Even; PinHeader_2x02_P2.54mm_Vertical
J6: Conn_02x05_Odd_Even; PinHeader_2x05_P1.27mm_Vertical_SMD
P2: USB_C_Plug; USB_C_Plug_Molex_105444
R1, R2: 5.1K; R_0402_1005Metric
R3: 10K; R_0402_1005Metric
U1: XC6206PxxxMR; SOT-23-3

Connections:
+3V3: C1.1, D1.1 (K), R3.1, U1.2 (VO)
/EXT_VBUS: J2.1, J4.1
/SRC_SBU1: J5.2, J6.2, R3.2
/SRC_SBU2: J5.3, J6.4
/SRC_VBUS: J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), J4.3
/TGT_SBU1: J5.1, P2.A8 (SBU1)
/TGT_SBU2: J5.4, P2.B8 (SBU2)
/TGT_VBUS: J4.2, P2.A4 (VBUS), P2.A9 (VBUS), P2.B4 (VBUS), P2.B9 (VBUS), U1.3 (VI)
/USB_DN: J1.A7 (D-), J1.B7 (D-), P2.A7 (D-)
/USB_DP: J1.A6 (D+), J1.B6 (D+), P2.A6 (D+)
GND: C1.2, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J3.1, J6.3, J6.5, P2.A1 (GND), P2.A12 (GND), P2.B1 (GND), P2.B12 (GND), P2.S1 (SHIELD), R1.1, R2.1, U1.1 (GND)
unnamed: D1.2 (A), J6.1
unnamed: J1.A5 (CC1), R1.2
unnamed: J1.B5 (CC2), R2.2

Board: 2 copper layers, 21.0 x 19.0 mm, 13 parts (0 on the bottom side), 14 nets.

## KiCad design Hardware/ioboard/pcb.kicad_pcb

Notes on the sheet:
CCD Power Supply
Power Plan
0.8 2024-01
System Power Supply
1. Use AD9990 for ADC/ AFE/ TG 2. Remove FPGA 3. Redesigned H/V driver
Table of Contents
USB
1. Add fan speed control 2. Add active lens contact 3. Add flash sync port 4. Allow tripod mount 5. Revise power supply design 6. Change connector type
1. Switch from iMX6ULL to iMXRT1176 2. Shrink board size 3. Removed builtin ethernet 4. CCD power supply bug fixes 5. Use MIPI DSI LCD instead of DPI
0.4 2022-03
1. Switch back to iMXRT1052 2. New board shape 3. Use 3.4" LCD instead of 4" 4. Split into 3 boards (MB, PB, SB) 5. Use individual MOSFETs for V-drivers
Microcontroller
1. Combine MB and PB into IOB 2. Switch to Zynq 7010 (AGAIN?) 3. Use FPGA for timing gen 4. Remove USB data port
Rev Date Description
0.7 2023-08
0.2 2021-03
Display
0.6 2023-03
Storage
1. Fix AD9990 TEST pin connection 2. Minor bug fixes for driver 3. Fix MPU power supply
0.5 2022-04
1. Redesign H/V driver (again)
Revision History
0.9 2024-03
1. Switch from iMXRT1052 to iMX6ULL 2. Use 4" 720x720 LCD instead 3. Add 100M ethernet 4. Redesigned CCD power supply 5. Bug fixes for driver level-shifter
0.1 2017-12
1. Initial release
Connectors
0.3 2021-12

Parts:
C90: 10uF; C_0603_1608Metric
J3: USB_C_Receptacle_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12
R19, R20: 5.1K 1%; R_0402_1005Metric
U7: USBLC6-2P6; SOT-666

Connections:
+5VP: C90.1, J3.A4 (VBUS), J3.A9 (VBUS), J3.B4 (VBUS), J3.B9 (VBUS), U7.5 (VBUS); also elsewhere on the board
MCU_SWCLK: J3.B8 (SBU2); also elsewhere on the board
MCU_SWDIO: J3.A8 (SBU1); also elsewhere on the board
unnamed: J3.A5 (CC1), R19.1
unnamed: J3.B5 (CC2), R20.1
USB_DN: J3.A7 (D-), J3.B7 (D-), U7.3 (I/O2), U7.4 (I/O2); also elsewhere on the board
USB_DP: J3.A6 (D+), J3.B6 (D+), U7.1 (I/O1), U7.6 (I/O1); also elsewhere on the board

Notes on the sheet:
power only port

Parts:
C1, C9: 22uF; C_0603_1608Metric; LCSC C116413
C3, C11, C12, C13, C14, C16, C17, C19, C20, C73, C85, C105: 10uF; C_0603_1608Metric
C4, C6, C7, C23, C24, C25: 4.7uF; C_0402_1005Metric
C5, C76: 220nF; C_0402_1005Metric
C10: 100nF; C_0402_1005Metric; LCSC C56392
C15, C18: 1nF; C_0402_1005Metric
C21, C22, C74, C75, C104: 100nF; C_0402_1005Metric
C77: 18pF; C_0402_1005Metric
C91, C93, C99, C102: 22uF; C_0603_1608Metric
D1: B0530WS; D_SOD-323
FID1, FID2, FID3, FID4, FID5, FID6: Fiducial; Fiducial_0.75mm_Mask1.5mm
H1, H2, H3: MountingHole; MountingHole_2.2mm_M2_DIN965
L1, L2, L3, L6, L9: FTC201610S4R7MBCA; L_Murata_DFE201610P
R1, R2: 1K; R_0402_1005Metric
R3: 200K; R_0402_1005Metric
R4, R27, R28, R30, R31, R32, R64, R65: 10K; R_0402_1005Metric
R5: 30mR; R_0603_1608Metric
R6: 1; R_0603_1608Metric
R10: 4.3K; R_0402_1005Metric
R33: 220K; R_0402_1005Metric
R34, R36, R62: 30K; R_0402_1005Metric
R63: 36K; R_0402_1005Metric
SW1: SW_Push_LED; TM-007-D1-X
U1: AXP209; QFN-48-1EP_6x6mm_P0.4mm_EP4.3x4.3mm_ThermalVias
U8: SY8120; TSOT-23-6
U9, U10, U11: MT9700; SOT-23-5
U12: SY7208; SOT-23-6

Connections:
+1V8: C14.2, C15.2, L2.2, U1.10 (DCDC2); also elsewhere on the board
+3.3VA: C25.2, U1.11 (LDO4); also elsewhere on the board
+3V3_LENS: C102.1, U11.1 (VOUT); also elsewhere on the board
+5VP: C85.1, U1.32 (ACIN), U1.33 (ACIN); also elsewhere on the board
+5V_LENS: C105.2, D1.1 (K), R33.2; also elsewhere on the board
+BATT: C1.1, C9.1, C10.1, C11.2, R5.2, U1.38 (BAT), U1.39 (BAT), U1.42 (BATSENSE); also elsewhere on the board
+CCDPWR: C99.1, U9.1 (VOUT); also elsewhere on the board
+VCCIO_SD: C21.2, U1.41 (LDO3)
+VSD: C22.2, U1.12 (LDO2); also elsewhere on the board
/power/PWRLED: R2.1, U1.18 (GPIO1)
/power/PWRON: R1.1, U1.47 (PWRON)
/power/VINT: C4.1, U1.26 (VINT), U1.27 (LDO1SET)
BACKUP_CELL: U1.30 (BACKUP)
DCDC_EN: R28.2, U9.4 (EN); also elsewhere on the board
EXTEN: U1.20 (EXTEN); also elsewhere on the board
FAN_EN: R30.2, U8.4 (~SHDN); also elsewhere on the board
FAN_PWM: R36.2; also elsewhere on the board
I2C_SCL: U1.2 (SCK); also elsewhere on the board
I2C_SDA: U1.1 (SDA); also elsewhere on the board
IPSOUT: C3.1, C5.1, C13.2, C16.2, C19.2, C24.2, R6.1, U1.7 (VIN2), U1.14 (VIN3), U1.21 (APS), U1.29 (DC3SET), U1.34 (IPSOUT), U1.35 (IPSOUT), U1.40 (LDO3IN), U1.44 (VIN_CHG), U9.5 (VIN), U10.5 (VIN); also elsewhere on the board
LENS_PWR_EN: R27.2, R31.2, U10.4 (EN), U11.4 (EN); also elsewhere on the board
unnamed: C76.2, R36.1, R62.2
unnamed: D1.2 (A), L9.2, U12.1 (SW)
unnamed: R1.2, SW1.2
unnamed: R2.2, SW1.4 (A)
unnamed: R3.1, U1.23 (BIAS)
unnamed: C12.2, L1.2, R5.1, U1.43 (CHSENSE)
unnamed: C7.1, U1.19 (GPIO0/LDOIO0)
unnamed: C20.2, R6.2, U1.13 (LDO24IN)
unnamed: L2.1, U1.8 (LX2)
unnamed: L3.1, U1.15 (LX3)
unnamed: L1.1, U1.45 (LX_CHG)
unnamed: C6.1, U1.24 (VREF)
unnamed: C75.2, U8.1 (BS)
unnamed: C77.1, R62.1, R63.1, R64.2, U8.3 (FB)
unnamed: C75.1, L6.1, U8.6 (SW)
unnamed: R10.2, U9.3 (SET)
unnamed: R65.2, U10.3 (SET)
unnamed: C93.1, C104.2, L9.1, U10.1 (VOUT), U12.4 (EN), U12.5 (IN)
unnamed: R32.2, U11.3 (SET)
unnamed: R33.1, R34.2, U12.3 (FB)
PMU_IRQ: U1.48 (IRQ)

Notes on the sheet:
Ilim = 0.68A
Ilim = 1.6A
Vout = adjustable from 1.0V to 2.7V
5.00V

Parts:
C78: 18pF; C_0402_1005Metric
C79: 22uF; C_0603_1608Metric
C80: 100nF; C_0402_1005Metric
C81: 470nF; C_0402_1005Metric
MICRO_SD400: MICRO_SD(TFC-WPAPR-08); TFC-WPAPR-08
R17: 22; R_0402_1005Metric
R18: 100K; R_0402_1005Metric
U4: W25Q32JV; WSON-8-1EP_6x5mm_P1.27mm_EP3.4x4.3mm

Connections:
+VSD: C79.1, C80.1; also elsewhere on the board
unnamed 84: C78.1, R17.1; also elsewhere on the board
unnamed 118: U4.3 (PC14); also elsewhere on the board
unnamed 119: U4.5 (PD0); also elsewhere on the board
unnamed 120: U4.6 (PD1); also elsewhere on the board

Parts:
C82, C86: 10uF; C_0603_1608Metric
C83, C84, C87: 100nF; C_0402_1005Metric
C88: 220nF; C_0402_1005Metric
C89: 10uF 25V; C_0805_2012Metric
D4: B0540W; D_SOD-323
J1: Hirose_FH12-20S-0.5SH_1x20-1MP_P0.50mm_Horizontal_Reversed
L5: 22uH; L_1212
R21, R23: 10K; R_0402_1005Metric
R22: 30K; R_0402_1005Metric
R24: 1K; R_0402_1005Metric
R25: 7.5; R_0402_1005Metric
U6: CAT4139; SOT-23-5

Connections:
/lcd/LEDA: C89.2, D4.1 (K), J1.4 (LEDA)
/lcd/LEDK: J1.2 (LEDK), R24.1, R25.1
LCD_EN: J1.9 (RESET), R21.1, U6.4 (~SHDN); also elsewhere on the board
LCD_PWM: R22.2; also elsewhere on the board
MIPI_CKN: J1.15 (MIPI_CLN); also elsewhere on the board
MIPI_CKP: J1.14 (MIPI_CLP); also elsewhere on the board
MIPI_D0N: J1.18 (MIPI_D0N); also elsewhere on the board
MIPI_D0P: J1.17 (MIPI_D0P); also elsewhere on the board
MIPI_D1N: J1.12 (MIPI_D1N); also elsewhere on the board
MIPI_D1P: J1.11 (MIPI_D1P); also elsewhere on the board
unnamed: C88.2, R22.1, R23.2
unnamed: D4.2 (A), L5.2, U6.1 (SW)
unnamed: R23.1, R24.2, U6.3 (FB)
