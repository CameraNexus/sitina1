# Repository CameraNexus/sitina1

File README.md:

# Sitina 1

Open-source 35mm full-frame (36mm x 24mm) CCD mirror-less interchangable lens camera (MILC). The original goal of this project was to create a digital camera back to convert SLR cameras to DSLR cameras, but has since changed to build a full MILC.

I have made 2 videos about this project:

- First video in 2023 (r0.6 hardware): [https://www.youtube.com/watch?v=Ma9FrN5COIo](https://www.youtube.com/watch?v=Ma9FrN5COIo)
- Second video in 2024 (r0.11-B hardware): [https://www.youtube.com/watch?v=OkfzjmY9cF8](https://www.youtube.com/watch?v=OkfzjmY9cF8)

Join discussion if you wish: [https://discord.gg/2zAJycbpU5](https://discord.gg/2zAJycbpU5)

## Specifications

The following are preliminary.

### Hardware

- SoC: Xilinx Zynq 7010 (2x667MHz Cortex-A9, 28K logic cells FPGA)
- RAM: 512MB 16-bit DDR3 SDRAM
- AFE: Analog Devices AD9990
- Sensor: Kodak/ONsemi KAI-11000/KAI-11002M/CM
- Screen: 3.4" 480x480 High-Brightness DPI IPS LCD
- External Ports:
  - SD slot (HS, 25MB/s)
  - USB Type-C (5V3A power supply)
  - Flash sync terminal

### Camera Features

The following are possible with hardware, but not necessarily supported by the current software.

- Sensor Type: 35mm Interline CCD sensor
- Sensor Size: 36.0 x 24.0 mm
- Effective Pixels: 10.7MP
- Lens Mount: Active E mount
- Still Resolutions:
  - 4008x2672 10.7MP 3:2
  - 3563x2672 9.5MP 4:3 1.08X crop
  - 2672x2672 7.1MP 1:1 1.27X crop
  - 2782x1856 5.2MP 3:2 APS-C crop
  - 2676x2007 5.4MP 4:3 APS-C crop
  - 2365x2365 5.6MP 1:1 APS-C crop
- Still Format:
  - DNG (10/12/14-bit lossless compressed RAW)
  - JPEG
- Readout Speed:
  - 4008x2672 up to 5FPS
  - 4008x480 at 28FPS (line skipping live view, rescaled to 480x320 for output)
- Video recording is not supported
- ISO: 100 to 6400 (color version)

## Status

Hardware R0.11 tested and working. The hardware still need a lot of work and is not ready yet.

## Sample Photos

## Revision History

See [old-versions.md](/OLD_VERSIONS.md) for change logs, stories, and photos of old revisions!

## License

Unless otherwise stated, the hardware design is released under CERN-OHL-P, and the software/ firmware are released under MIT.

Most other 3D models are obtained from vendor website, refer to the corresponding vendor website for licensing details. They are provided for convience only.

## KiCad design hardware/jtag_adapter/jtag_adapter.kicad_pcb

Board: 2 copper layers, 21.5 x 14.0 mm, 5 parts (1 on the bottom side), 10 nets.

Parts:
D1, D2: B0540W; D_SOD-323
J1: Conn_02x06_Odd_Even; PinHeader_2x06_P1.27mm_Vertical_SMD
J2: Conn_02x07_Odd_Even; PinHeader_2x06_P2.00mm_Vertical_SMD
J6: Conn_02x05_Odd_Even; PinHeader_2x05_P1.27mm_Vertical_SMD

Connections:
+3V3: D1.1 (K), D2.1 (K), J1.12
FPGA_TCK: J1.1, J2.6
FPGA_TDI: J1.3, J2.10
FPGA_TDO: J1.5, J2.8
FPGA_TMS: J1.7, J2.4
GND: J1.2, J1.4, J1.6, J1.8, J1.10, J2.3, J2.5, J2.7, J2.9, J2.11, J6.3, J6.5, J6.9
MCU_SWCLK: J1.9, J6.4
MCU_SWDIO: J1.11, J6.2
unnamed: D1.2 (A), J6.1
unnamed: D2.2 (A), J2.2

## KiCad design hardware/ioboard/pcb.kicad_pcb

Notes on the sheet:
CCD Power Supply
Power Plan
System Power Supply
Table of Contents
USB
Microcontroller
Display
Storage
Connectors

Parts:
C90: 10uF; C_0603_1608Metric
J3: USB_C_Receptacle_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12
R19, R20: 5.1K; R_0402_1005Metric
U7: USBLC6-2P6; SOT-666

Connections:
+5VP: C90.1, J3.A4 (VBUS), J3.A9 (VBUS), J3.B4 (VBUS), J3.B9 (VBUS), U7.5 (VBUS); also elsewhere on the board
GND: C90.2, J3.A1 (GND), J3.A12 (GND), J3.B1 (GND), J3.B12 (GND), J3.S1 (SHIELD), R19.2, R20.2, U7.2 (GND); also elsewhere on the board
unnamed: J3.A5 (CC1), R19.1
unnamed: J3.B5 (CC2), R20.1
USB_DN: J3.A7 (D-), J3.B7 (D-), U7.3 (I/O2), U7.4 (I/O2)
USB_DP: J3.A6 (D+), J3.B6 (D+), U7.1 (I/O1), U7.6 (I/O1)

Notes on the sheet:
power only port

Parts:
C1, C9, C93, C99, C102: 22uF; C_0603_1608Metric
C2, C60, C68, C69, C70, C71, C73, C74, C75, C76, C77, C81, C91, C94, C95, C96: 47uF; C_0805_2012Metric
C3, C11, C12, C13, C14, C16, C17, C19, C20, C85, C105: 10uF; C_0603_1608Metric
C4, C6, C7, C23, C24, C25: 4.7uF; C_0402_1005Metric
C5: 470nF; C_0402_1005Metric
C10, C21, C22, C104: 100nF; C_0402_1005Metric
C15, C18: 1nF; C_0402_1005Metric
D1: B0540WS; D_SOD-323
FID1, FID2, FID3, FID4, FID5, FID6: Fiducial; Fiducial_0.75mm_Mask1.5mm
H1, H2, H3: MountingHole; MountingHole_2.2mm_M2_DIN965
L1, L2, L3, L9: FTC201610S4R7MBCA; L_Murata_DFE201610P
R1, R2: 1K; R_0402_1005Metric
R3: 200K; R_0402_1005Metric
R4, R10, R27, R28, R31, R32, R65: 10K; R_0402_1005Metric
R5: 30mR; R_0603_1608Metric
R6: 1; R_0603_1608Metric
R33: 220K; R_0402_1005Metric
R34: 30K; R_0402_1005Metric
SW1: C725874; TM-007-D1-X
U1: AXP209; QFN-48-1EP_6x6mm_P0.4mm_EP4.3x4.3mm_ThermalVias
U9, U10, U11: MT9700; SOT-23-5
U12: SY7208; SOT-23-6

Connections:
+1V8: C14.2, C15.2, L2.2, U1.10 (DCDC2); also elsewhere on the board
+3.3VA: C25.2, U1.11 (LDO4); also elsewhere on the board
+3V3: C17.2, C18.2, L3.2, R4.1, U1.17 (DCDC3), U11.5 (VIN); also elsewhere on the board
+3V3_LENS: C102.1, U11.1 (VOUT); also elsewhere on the board
+5VP: C85.1, U1.32 (ACIN), U1.33 (ACIN); also elsewhere on the board
+5V_LENS: C105.2, D1.1 (K), R33.2; also elsewhere on the board
+BATT: C1.1, C9.1, C10.1, C11.2, R5.2, U1.38 (BAT), U1.39 (BAT), U1.42 (BATSENSE); also elsewhere on the board
+RTC: C23.2, U1.28 (LDO1); also elsewhere on the board
+VSD: C22.2, U1.12 (LDO2); also elsewhere on the board
/power/PWRLED: R2.1, U1.18 (GPIO1)
/power/PWRON: R1.1, U1.47 (PWRON)
/power/VINT: C4.1, U1.26 (VINT), U1.27 (LDO1SET)
BACKUP_CELL: U1.30 (BACKUP)
DCDC_EN: R28.2, U9.4 (EN); also elsewhere on the board
EXTEN: U1.20 (EXTEN); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C9.2, C10.2, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C60.2, C68.2, C69.2, C70.2, C71.2, C73.2, C74.2, C75.2, C76.2, C77.2, C81.2, C85.2, C91.2, C93.2, C94.2, C95.2, C96.2, C99.2, C102.2, C104.1, C105.1, R3.2, R10.1, R27.1, R28.1, R31.1, R32.1, R34.1, R65.1, SW1.1, SW1.3 (K), U1.4 (~OE), U1.6 (~VBUSEN), U1.9 (PGND2), U1.16 (PGND3), U1.22 (AGND), U1.46 (PGND_CHG), U1.49 (EP), U9.2 (GND), U10.2 (GND), U11.2 (GND), U12.2 (GND); also elsewhere on the board
I2C2_SCL: U1.2 (SCK); also elsewhere on the board
I2C2_SDA: U1.1 (SDA); also elsewhere on the board
LENS_PWR_EN: R27.2, R31.2, U10.4 (EN), U11.4 (EN); also elsewhere on the board
unnamed: D1.2 (A), L9.2, U12.1 (SW)
unnamed: R1.2, SW1.2
unnamed: R2.2, SW1.4 (A)
unnamed: R3.1, U1.23 (BIAS)
unnamed: C12.2, L1.2, R5.1, U1.43 (CHSENSE)
unnamed: C7.1, U1.19 (GPIO0/LDOIO0)
unnamed: C21.2, U1.41 (LDO3)
unnamed: C20.2, R6.2, U1.13 (LDO24IN)
unnamed: L2.1, U1.8 (LX2)
unnamed: L3.1, U1.15 (LX3)
unnamed: L1.1, U1.45 (LX_CHG)
unnamed: C6.1, U1.24 (VREF)
unnamed: R10.2, U9.3 (SET)
unnamed: R65.2, U10.3 (SET)
unnamed: C93.1, C104.2, L9.1, U10.1 (VOUT), U12.4 (EN), U12.5 (IN)
unnamed: R32.2, U11.3 (SET)
unnamed: R33.1, R34.2, U12.3 (FB)
PMU_IRQ: U1.48 (IRQ)
PWROK: R4.2, U1.25 (PWROK); also elsewhere on the board

Notes on the sheet:
Ilim = 0.68A
5.00V

Parts:
C78: 18pF; C_0402_1005Metric
C79: 22uF; C_0603_1608Metric
C80: 100nF; C_0402_1005Metric
MICRO_SD400: MICRO_SD(TFC-WPAPR-08); TFC-WPAPR-08
R17: 22; R_0402_1005Metric

Connections:
+VSD: C79.1, C80.1; also elsewhere on the board
GND: C78.2, C79.2, C80.2; also elsewhere on the board
unnamed 78: C78.1, R17.1; also elsewhere on the board
SDIO_CLK: R17.2; also elsewhere on the board

Parts:
C82, C86: 10uF; C_0603_1608Metric
C83, C84, C87: 100nF; C_0402_1005Metric
C88: 470nF; C_0402_1005Metric
C89: 10uF 25V; C_0805_2012Metric
D4: B0540WS; D_SOD-323
J1: Hirose_FH12-20S-0.5SH_1x20-1MP_P0.50mm_Horizontal_Reversed
L5: YHNR3015-220M; L_Changjiang_FNR3015S
R21: 10K; R_0402_1005Metric
R22: 30K; R_0402_1005Metric
R23: 5.1K; R_0402_1005Metric
R24: 1K; R_0402_1005Metric
R25: 7.5; R_0402_1005Metric
U6: CAT4139; SOT-23-5

Connections:
+3V3: C82.2, C83.1, C84.1, C86.2, C87.2, J1.6 (VDD), J1.7 (IOVCC), L5.1, U6.5 (IN); also elsewhere on the board
/lcd/LEDA: C89.2, D4.1 (K), J1.4 (LEDA)
/lcd/LEDK: J1.2 (LEDK), R24.1, R25.1
GND: C82.1, C83.2, C84.2, C86.1, C87.1, C88.1, C89.1, J1.10 (GND), J1.13 (GND), J1.16 (GND), J1.19 (GND), J1.20 (GND), R21.2, R25.2, U6.2 (GND); also elsewhere on the board
LCD_EN: J1.9 (RESET), R21.1, U6.4 (~SHDN); also elsewhere on the board
LCD_PWM: R22.2; also elsewhere on the board
MIPI_CKN: J1.15 (MIPI_CLN); also elsewhere on the board
MIPI_CKP: J1.14 (MIPI_CLP); also elsewhere on the board
MIPI_D0N: J1.18 (MIPI_D0N); also elsewhere on the board
MIPI_D0P: J1.17 (MIPI_D0P); also elsewhere on the board
MIPI_D1N: J1.12 (MIPI_D1N); also elsewhere on the board
MIPI_D1P: J1.11 (MIPI_D1P); also elsewhere on the board
unnamed: C88.2, R22.1, R23.2
unnamed: D4.2 (A), L5.2, U6.1 (SW)
unnamed: R23.1, R24.2, U6.3 (FB)

Parts:
J2, J5: 0.5mm Bottom Contact; Hirose_FH12-30S-0.5SH_1x30-1MP_P0.50mm_Horizontal
J7: 0.5mm Bottom Contact; Hirose_FH12-12S-0.5SH_1x12-1MP_P0.50mm_Horizontal
J8: AudioJack2; Jack_2.5mm_PJ_210A
J9: Conn_02x06_Odd_Even; PinSocket_2x06_P1.27mm_Horizontal
J12, J13, J14, J15, J16, J17, J18, J19, J20, J21: LensMount; YZP0652-15072-01
R8: 200R; R_0402_1005Metric
U5: FODM3023; MFP4_3.85x4.4

Connections:
+1V8: J5.1; also elsewhere on the board
+2VD: J2.28; also elsewhere on the board
+3.3VA: J2.16; also elsewhere on the board
+3V3: J5.7, J5.8, J9.12; also elsewhere on the board
+3V3_LENS: J16.1; also elsewhere on the board
+5VD: J2.2, J2.3; also elsewhere on the board
+5V_LENS: J13.1; also elsewhere on the board
+8VD: J2.10, J2.11, J2.12; also elsewhere on the board
+16VA: J2.17, J2.18; also elsewhere on the board
+16VD: J2.26; also elsewhere on the board
+BATT: J7.8, J7.9, J7.10; also elsewhere on the board
+RTC: J7.11; also elsewhere on the board
-4VD: J2.4, J2.23, J2.24; also elsewhere on the board
-8VA: J2.19; also elsewhere on the board
-9VD: J2.7, J2.8, J2.9; also elsewhere on the board
-15VD: J2.30; also elsewhere on the board
BODY_CS_LENS: J20.1; also elsewhere on the board
BODY_VD_LENS: J15.1; also elsewhere on the board
CCD_AFE_SYNC: J2.22
CCD_PULSE_SYNC: J2.21
EXTEN: J5.5; also elsewhere on the board
FLASH_SYNC: R8.1; also elsewhere on the board
FLASH_SYNC_S: J8.S, U5.4
FLASH_SYNC_T: J8.T, U5.3
FPGA_TCK: J5.16, J9.1
FPGA_TDI: J5.17, J9.3
FPGA_TDO: J5.18, J9.5
FPGA_TMS: J5.19, J9.7
GND: J2.1, J2.5, J2.6, J2.13, J2.14, J2.15, J2.20, J2.25, J2.27, J2.29, J2.MP (MountPin), J5.2, J5.6, J5.9, J5.23, J5.30, J5.MP (MountPin), J7.5, J7.6, J7.7, J7.12, J7.MP (MountPin), J9.2, J9.4, J9.6, J9.8, J9.10, J12.1, J14.1, U5.2; also elsewhere on the board
GRIP_CS: J7.3; also elsewhere on the board
GRIP_MISO: J7.4; also elsewhere on the board
GRIP_MOSI: J7.2; also elsewhere on the board
GRIP_SCK: J7.1; also elsewhere on the board
I2C1_SDA: J5.22; also elsewhere on the board
LENS_CS_BODY: J17.1; also elsewhere on the board
LENS_DET: J21.1; also elsewhere on the board
LENS_RXD: J18.1; also elsewhere on the board
LENS_TXD: J19.1; also elsewhere on the board
MCU_SWCLK: J9.9; also elsewhere on the board
MCU_SWDIO: J9.11; also elsewhere on the board
MIPI_CKN: J5.24; also elsewhere on the board
MIPI_CKP: J5.25; also elsewhere on the board
MIPI_D0N: J5.26; also elsewhere on the board
MIPI_D0P: J5.27; also elsewhere on the board
MIPI_D1N: J5.28; also elsewhere on the board
MIPI_D1P: J5.29; also elsewhere on the board
unnamed: R8.2, U5.1
PS_POR_B: J5.20; also elsewhere on the board
SDIO_CLK: J5.10; also elsewhere on the board
SDIO_CMD: J5.11; also elsewhere on the board
SDIO_DAT0: J5.12; also elsewhere on the board
SDIO_DAT1: J5.13; also elsewhere on the board
SDIO_DAT2: J5.14; also elsewhere on the board
SDIO_DAT3: J5.15; also elsewhere on the board

Notes on the sheet:
PULSE
To Sensor Board J2
To Grip Board
SENSITIVE
To Sensor Board J1
Flash Sync
HIGH POWER PULSE

Notes on the sheet:
SY7208
Sensor Board
page 7 - U515, U516
+CCDPWR
SENSITIVE
+VSD
HIGH POWER PULSE
+SYS
+15VL
page 6 - U508
SWLM1.4A
+3V3
+15VR
Consumers
DCDC3
VCI
Backlight
OLM0.03A
STM32G0
+1V5
SYNC
+RTC
2.5A
OLM<1A
page 6 - U509-513
ESD
IPSOUT Internal Supply
VDDR
LT3045
+16V
Legends
Power Board
ADP5071
IMXRT1052
H1BL H2BL
+1V8
MT9700
+2V
Capability
PULSE

Parts:
C2, C32, C34, C35, C36, C62, C69, C70, C71: 47uF; C_0805_2012Metric
C8, C26, C27, C30, C43, C44, C45, C48: 470nF; C_0402_1005Metric
C28, C31, C46, C49: 4.7nF; C_0402_1005Metric
C29, C37, C47, C50: 10nF; C_0402_1005Metric
C38, C39, C51, C52, C61: 18pF; C_0402_1005Metric
C40, C41, C53, C54: DNP; C_0402_1005Metric
C42, C55, C56, C57, C58, C63, C64, C67: 10uF 25V; C_0805_2012Metric
C59: 100nF; C_0402_1005Metric
D3, D5, D6, D7, D8, D9, D10, D11: B0540WS; D_SOD-323
L4, L6, L8, L10, L13, L14, L15, L16: YHNR3015-4R7M; L_Changjiang_FNR3015S
L7: FTC201610S4R7MBCA; L_Murata_DFE201610P
R7, R9, R50, R51: 100; R_0402_1005Metric
R12, R14: 30K; R_0402_1005Metric
R13, R29: 200K; R_0402_1005Metric
R15, R57, R61: 220K; R_0402_1005Metric
R16, R53, R55, R58: 270K; R_0402_1005Metric
R26, R54, R59: 22K; R_0402_1005Metric
R30: 36K; R_0402_1005Metric
R52: 82K; R_0402_1005Metric
R56: 680K; R_0402_1005Metric
R60: 510K; R_0402_1005Metric
U2, U3, U13, U14: TPS65131RGE; VQFN-24-1EP_4x4mm_P0.5mm_EP2.45x2.45mm_0.3ThermalVias
U8: SY8008; TSOT-23-5

Connections:
+2VD: C61.1, C62.1, L7.2, R60.1; also elsewhere on the board
+5VD: C51.1, C56.1, D8.1 (K), R56.1, U13.23 (VPOS); also elsewhere on the board
+8VD: C39.1, C64.1, D5.1 (K), R29.1, U3.23 (VPOS); also elsewhere on the board
+16VA: C38.1, C42.1, D3.1 (K), R16.1, U2.23 (VPOS); also elsewhere on the board
+16VD: C52.1, C57.1, D9.1 (K), R58.1, U14.23 (VPOS); also elsewhere on the board
-4VD: C53.2, C58.1, D10.2 (A), R53.2, U13.15 (VNEG); also elsewhere on the board
-8VA: C40.2, C63.1, D6.2 (A), R13.2, U2.15 (VNEG); also elsewhere on the board
-9VD: C41.2, C67.1, D7.2 (A), R15.2, U3.15 (VNEG); also elsewhere on the board
-15VD: C54.2, C55.1, D11.2 (A), R55.2, U14.15 (VNEG); also elsewhere on the board
CCD_POWEREN: U2.8 (ENP), U2.10 (ENN), U3.8 (ENP), U3.10 (ENN), U8.1 (~SHDN), U13.8 (ENP), U13.10 (ENN), U14.8 (ENP), U14.10 (ENN); also elsewhere on the board
GND: C2.2, C8.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C34.2, C35.2, C36.2, C37.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C55.2, C56.2, C57.2, C58.2, C59.1, C62.2, C63.2, C64.2, C67.2, C69.2, C70.2, C71.2, L8.1, L10.1, L15.1, L16.1, R26.2, R30.2, R57.2, R59.2, R61.2, U2.2 (PGND), U2.3 (PGND), U2.19 (AGND), U2.25 (EP), U3.2 (PGND), U3.3 (PGND), U3.19 (AGND), U3.25 (EP), U8.2 (GND), U13.2 (PGND), U13.3 (PGND), U13.19 (AGND), U13.25 (EP), U14.2 (PGND), U14.3 (PGND), U14.19 (AGND), U14.25 (EP); also elsewhere on the board
unnamed: D3.2 (A), L4.1, U2.1 (INP), U2.24 (INP)
unnamed: D5.2 (A), L6.1, U3.1 (INP), U3.24 (INP)
unnamed: D6.1 (K), L8.2, U2.13 (OUTN), U2.14 (OUTN)
unnamed: D7.1 (K), L10.2, U3.13 (OUTN), U3.14 (OUTN)
unnamed: D8.2 (A), L13.1, U13.1 (INP), U13.24 (INP)
unnamed: D9.2 (A), L14.1, U14.1 (INP), U14.24 (INP)
unnamed: D10.1 (K), L15.2, U13.13 (OUTN), U13.14 (OUTN)
unnamed: D11.1 (K), L16.2, U14.13 (OUTN), U14.14 (OUTN)
unnamed: C28.1, U2.18 (CN)
unnamed: C29.1, U2.21 (CP)
unnamed: C40.1, R12.2, R13.1, U2.16 (FBN)
unnamed: C38.2, R16.2, R26.1, U2.22 (FBP)
unnamed: C8.1, R7.1, U2.4 (VIN), U2.9 (PSP), U2.11 (PSN)
unnamed: C27.1, R12.1, U2.17 (VREF)
unnamed: C31.1, U3.18 (CN)
unnamed: C37.1, U3.21 (CP)
unnamed: C41.1, R14.2, R15.1, U3.16 (FBN)
unnamed: C39.2, R29.2, R30.1, U3.22 (FBP)
unnamed: C26.1, R9.1, U3.4 (VIN), U3.9 (PSP), U3.11 (PSN)
unnamed: C30.1, R14.1, U3.17 (VREF)
unnamed: C61.2, R60.2, R61.1, U8.5 (FB)
unnamed: L7.1, U8.3 (SW)
unnamed: C46.1, U13.18 (CN)
unnamed: C47.1, U13.21 (CP)
unnamed: C53.1, R52.2, R53.1, U13.16 (FBN)
unnamed: C51.2, R56.2, R57.1, U13.22 (FBP)
unnamed: C43.1, R50.1, U13.4 (VIN), U13.9 (PSP), U13.11 (PSN)
unnamed: C45.1, R52.1, U13.17 (VREF)
unnamed: C49.1, U14.18 (CN)
unnamed: C50.1, U14.21 (CP)
unnamed: C54.1, R54.2, R55.1, U14.16 (FBN)
unnamed: C52.2, R58.2, R59.1, U14.22 (FBP)
unnamed: C44.1, R51.1, U14.4 (VIN), U14.9 (PSP), U14.11 (PSN)
unnamed: C48.1, R54.1, U14.17 (VREF)

Notes on the sheet:
-3.99V
4.96V
-8.09V
7.95V
-14.89V
16.10V
1.99V
-8.90V

Schematic: mcu.kicad_sch, Housekeeping Microcontroller

Parts:
BZ1: Buzzer; Buzzer_Murata_PKMCS0909E
C33: 10uF; C_0603_1608Metric
C65, C66: 18pF; C_0402_1005Metric
C72, C92: 100nF; C_0402_1005Metric
D2: LED; LED_0603_1608Metric
R11, R18, R35: 10K; R_0402_1005Metric
R37: 1K; R_0402_1005Metric
U4: STM32G030K6Tx; LQFP-32_7x7mm_P0.8mm
Y2: 32.768K; Crystal_SMD_TXC_9HT11-2Pin_2.0x1.2mm_HandSoldering

Connections:
+RTC: C33.1, C92.1, R11.1, U4.4 (VDD); also elsewhere on the board
/mcu/BEEPER: R37.2, U4.27 (PB3)
/mcu/LED_R: R35.1, U4.32 (PB8)
BODY_CS_LENS: U4.29 (PB5); also elsewhere on the board
BODY_VD_LENS: U4.15 (PB0); also elsewhere on the board
CCD_POWEREN: U4.17 (PB2); also elsewhere on the board
DCDC_EN: U4.16 (PB1); also elsewhere on the board
FLASH_SYNC: U4.1 (PB9); also elsewhere on the board
GND: BZ1.2 (-), C33.2, C65.1, C66.1, C72.1, C92.2, D2.1 (K), R18.1, U4.5 (VSS); also elsewhere on the board
GRIP_CS: U4.11 (PA4); also elsewhere on the board
GRIP_MISO: U4.13 (PA6); also elsewhere on the board
GRIP_MOSI: U4.14 (PA7); also elsewhere on the board
GRIP_SCK: U4.12 (PA5); also elsewhere on the board
I2C1_SDA: U4.21 (PA10/NC); also elsewhere on the board
I2C2_SCL: U4.22 (PA11/PA9); also elsewhere on the board
I2C2_SDA: U4.23 (PA12/PA10); also elsewhere on the board
LCD_EN: U4.31 (PB7); also elsewhere on the board
LCD_PWM: U4.28 (PB4); also elsewhere on the board
LENS_CS_BODY: U4.18 (PA8); also elsewhere on the board
LENS_DET: U4.7 (PA0); also elsewhere on the board
LENS_PWR_EN: U4.8 (PA1); also elsewhere on the board
LENS_RXD: U4.10 (PA3); also elsewhere on the board
LENS_TXD: U4.9 (PA2); also elsewhere on the board
MCU_SWCLK: R18.2, U4.25 (PA14); also elsewhere on the board
MCU_SWDIO: U4.24 (PA13); also elsewhere on the board
unnamed: BZ1.1 (+), R37.1
unnamed: D2.2 (A), R35.2
unnamed: C72.2, R11.2, U4.6 (NRST)
unnamed: C65.2, U4.2 (PC14), Y2.1
unnamed: C66.2, U4.3 (PC15), Y2.2
PS_POR_B: U4.30 (PB6); also elsewhere on the board
PWROK: U4.26 (PA15); also elsewhere on the board

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

Notices in the files:
Hardware/ioboard/mcu.kicad_sch:
Copyright 2024 Wenting Zhang, Anhang Li
Hardware/ioboard/pcb.kicad_pcb:
Copyright 2023 Wenting Zhang
This source describes Open Hardware and is licensed under the CERN-OHL-S v2.
Hardware/powerboard/PowerBoard.kicad_pcb:
(c) 2023 Anhang Li, Wenting Zhang
Hardware/sensorboard/pcb.kicad_pcb:
Copyright 2022 Wenting Zhang
(c) 2023 Wenting, Anhang
hardware/ioboard/mcu.kicad_sch:
Copyright 2024 Anhang Li, Wenting Zhang
This source describes Open Hardware and is licensed under the CERN-OHL-P v2.
