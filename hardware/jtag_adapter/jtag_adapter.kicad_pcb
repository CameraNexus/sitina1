# Repository CameraNexus/sitina1 (continued)

## KiCad design Hardware/ioboard/pcb.kicad_pcb (continued)

Parts:
C81, C100, C101, C108: 22uF; C_0603_1608Metric
J2, J5: 0.5mm Bottom Contact; Hirose_FH12-30S-0.5SH_1x30-1MP_P0.50mm_Horizontal
J4, J6, J10, J11: 2.54mm pitch; PinSocket_1x02_P2.54mm_Vertical
J7: 0.5mm Bottom Contact; Hirose_FH12-12S-0.5SH_1x12-1MP_P0.50mm_Horizontal
J8: AudioJack2; Jack_2.5mm_PJ_210A
J12, J13, J14, J15, J16, J17, J18, J19, J20, J21: LensMount; YTC1P-4520
R8: 200R; R_0402_1005Metric
U5: FODM3023; SMDIP-4_W7.62mm

Connections:
+1V8: J5.30; also elsewhere on the board
+2VD: J2.3; also elsewhere on the board
+3.3VA: J2.15; also elsewhere on the board
+3V3_LENS: J16.1; also elsewhere on the board
+5VD: J2.28, J2.29; also elsewhere on the board
+5V_LENS: J13.1; also elsewhere on the board
+8VD: J2.19, J2.20, J2.21; also elsewhere on the board
+16VA: J2.13, J2.14; also elsewhere on the board
+16VD: J2.5; also elsewhere on the board
+BATT: J7.8, J7.9, J7.10; also elsewhere on the board
-4VD: J2.7, J2.8, J2.27; also elsewhere on the board
-9VA: J2.12; also elsewhere on the board
-9VD: J2.22, J2.23, J2.24; also elsewhere on the board
-15VD: J2.1; also elsewhere on the board
BODY_CS_LENS: J20.1; also elsewhere on the board
BODY_VD_LENS: J15.1; also elsewhere on the board
CCD_AFE_SYNC: J2.9; also elsewhere on the board
CCD_PULSE_SYNC: J2.10; also elsewhere on the board
EXTEN: J5.26; also elsewhere on the board
FLASH_SYNC_S: J8.S, U5.4
FLASH_SYNC_T: J8.T, U5.3
FPGA_TCK: J5.15; also elsewhere on the board
FPGA_TDI: J5.14; also elsewhere on the board
FPGA_TDO: J5.13; also elsewhere on the board
FPGA_TMS: J5.12; also elsewhere on the board
GRIP_CS: J7.3; also elsewhere on the board
GRIP_MISO: J7.4; also elsewhere on the board
GRIP_MOSI: J7.2; also elsewhere on the board
GRIP_SCK: J7.1; also elsewhere on the board
I2C_SCL: J5.10; also elsewhere on the board
I2C_SDA: J5.9; also elsewhere on the board
IPSOUT: J5.27, J5.28; also elsewhere on the board
LENS_CS_BODY: J17.1; also elsewhere on the board
LENS_DET: J21.1; also elsewhere on the board
LENS_RXD: J18.1; also elsewhere on the board
LENS_TXD: J19.1; also elsewhere on the board
MIPI_CKN: J5.7; also elsewhere on the board
MIPI_CKP: J5.6; also elsewhere on the board
MIPI_D0N: J5.5; also elsewhere on the board
MIPI_D0P: J5.4; also elsewhere on the board
MIPI_D1N: J5.3; also elsewhere on the board
MIPI_D1P: J5.2; also elsewhere on the board
unnamed: R8.2, U5.1
PS_POR_B: J5.11; also elsewhere on the board

Notes on the sheet:
PULSE
To Sensor Board J2
To System Fan
To Grip Board
SENSITIVE
To Sensor Board J1
Flash Sync
HIGH POWER PULSE

Notes on the sheet:
+VSD
page 7 - U520
page 6 - U509-513
LT3045
PMIC AXP209
LDO2
MT9700
+1V8
IRF9389
Sensor Board
74HC2G17
HIGH POWER PULSE
ILM1.7A
XC6206
OLM0.2A
VCI
PULSE
1EDN7550B
+15VL
page 7 - U518, U519
SNVS
USBC-1
SDRAM
H2BR H1BR
Power Board
LDO4
+3.2~4.2
SENSITIVE
RDIV
ADA4800 PreAmp
OLM0.03A
page 7 - U517
19.2V 40mA
page 7 - U514
Legends
Charge LM 1.8A
+5VP
+VCCIO_SD
+CCDPWR
+3V3_LENS

Parts:
C2, C32, C34, C35, C36, C62, C69, C70, C71, C72: 47uF; C_0805_2012Metric
C8, C26, C37, C38: 2.2uF; C_0402_1005Metric
C27, C28, C29, C30: 47nF; C_0402_1005Metric
C39, C40, C41, C42, C55, C57: 10uF 25V; C_0805_2012Metric
C43, C44, C45, C48: 220nF; C_0402_1005Metric
C46, C49: 4.7nF; C_0402_1005Metric
C47, C50: 10nF; C_0402_1005Metric
C51, C52, C61: 22pF; C_0402_1005Metric
C53, C54: DNP; C_0402_1005Metric
C56, C58: 10uF; C_0603_1608Metric
C59, C60: 100nF; C_0402_1005Metric
D3, D5, D6, D7, D8, D9, D10, D11: B0540W; D_SOD-323
L4, L10, L11, L12, L13, L14, L15, L16: 4.7uH; L_1212
L7: FTC201610S4R7MBCA; L_Murata_DFE201610P
R7, R9, R12, R13: 12K; R_0402_1005Metric
R11: 10K; R_0402_1005Metric
R15, R16, R38, R39, R40, R41: DNP; R_0402_1005Metric
R42: 27K; R_0402_1005Metric
R43, R45, R54, R59: 22K; R_0402_1005Metric
R44: 30K; R_0402_1005Metric
R46, R60: 510K; R_0402_1005Metric
R47, R48, R49, R53, R55, R58: 270K; R_0402_1005Metric
R50, R51: 100; R_0402_1005Metric
R52: 82K; R_0402_1005Metric
R56: 680K; R_0402_1005Metric
R57, R61: 220K; R_0402_1005Metric
U2, U3: ADP5071ACPZ; LFCSP-20-1EP_4x4mm_P0.5mm_EP2.6x2.6mm_ThermalVias
U13, U14: TPS65130RGE; VQFN-24-1EP_4x4mm_P0.5mm_EP2.45x2.45mm_0.3ThermalVias
U15: SY8120; TSOT-23-6

Connections:
+2VD: C61.1, C62.1, L7.2, R60.1; also elsewhere on the board
+5VD: C51.1, C55.1, D8.1 (K), R56.1, U13.23 (VPOS); also elsewhere on the board
+8VD: C42.1, D7.1 (K), R48.2; also elsewhere on the board
+16VA: C40.1, D6.1 (K), R46.2; also elsewhere on the board
+16VD: C52.1, C57.1, D9.1 (K), R58.1, U14.23 (VPOS); also elsewhere on the board
+CCDPWR: C2.1, C32.1, C34.1, C35.1, C36.1, C59.2, C69.1, C70.1, C71.1, C72.1, L13.2, L14.2, R11.1, R50.2, R51.2, U2.15 (PVIN1), U2.16 (PVINSYS), U2.17 (PVIN2), U3.15 (PVIN1), U3.16 (PVINSYS), U3.17 (PVIN2), U13.5 (INN), U13.6 (INN), U14.5 (INN), U14.6 (INN), U15.5 (IN); also elsewhere on the board
-4VD: C53.2, C56.1, D10.2 (A), R53.2, U13.15 (VNEG); also elsewhere on the board
-9VA: C41.1, D3.2 (A), R47.2; also elsewhere on the board
-9VD: C39.1, D5.2 (A), R49.2; also elsewhere on the board
-15VD: C54.2, C58.1, D11.2 (A), R55.2, U14.15 (VNEG); also elsewhere on the board
CCD_AFE_SYNC: U2.2 (SYNC/FREQ); also elsewhere on the board
CCD_POWEREN: R11.2, U2.7 (EN1), U2.9 (EN2), U3.7 (EN1), U3.9 (EN2), U13.8 (ENP), U13.10 (ENN), U14.8 (ENP), U14.10 (ENN), U15.4 (~SHDN)
CCD_PULSE_SYNC: U3.2 (SYNC/FREQ); also elsewhere on the board
unnamed: C27.2, R7.2
unnamed: C28.2, R9.2
unnamed: C29.2, R12.2
unnamed: C30.2, R13.2
unnamed: D3.1 (K), L11.2, U2.18 (SW2)
unnamed: D5.1 (K), L12.2, U3.18 (SW2)
unnamed: D6.2 (A), L4.1, U2.20 (SW1)
unnamed: D7.2 (A), L10.1, U3.20 (SW1)
unnamed: D8.2 (A), L13.1, U13.1 (INP), U13.24 (INP)
unnamed: D9.2 (A), L14.1, U14.1 (INP), U14.24 (INP)
unnamed: D10.1 (K), L15.2, U13.13 (OUTN), U13.14 (OUTN)
unnamed: D11.1 (K), L16.2, U14.13 (OUTN), U14.14 (OUTN)
unnamed: R7.1, U2.6 (COMP1)
unnamed: R12.1, U2.10 (COMP2)
unnamed: R42.1, R46.1, U2.5 (FB1)
unnamed: R43.1, R47.1, U2.11 (FB2)
unnamed: L4.2, U2.1 (INBK)
unnamed: R40.1, U2.3 (SEQ)
unnamed: R38.1, U2.4 (SLEW)
unnamed: R15.1, U2.8 (SS)
unnamed: C37.2, R43.2, U2.12 (VREF)
unnamed: C8.2, U2.14 (VREG)
unnamed: R9.1, U3.6 (COMP1)
unnamed: R13.1, U3.10 (COMP2)
unnamed: R44.1, R48.1, U3.5 (FB1)
unnamed: R45.1, R49.1, U3.11 (FB2)
unnamed: L10.2, U3.1 (INBK)
unnamed: R41.1, U3.3 (SEQ)
unnamed: R39.1, U3.4 (SLEW)
unnamed: R16.1, U3.8 (SS)
unnamed: C38.2, R45.2, U3.12 (VREF)
unnamed: C26.2, U3.14 (VREG)
unnamed: C46.1, U13.18 (CN)
unnamed: C47.1, U13.21 (CP)
unnamed: C53.1, R52.2, R53.1, U13.16 (FBN)
unnamed: C51.2, R56.2, R57.1, U13.22 (FBP)
unnamed: C43.1, R50.1, U13.4 (VIN), U13.9 (PSP), U13.11 (PSN)
unnamed: C45.1, R52.1, U13.17 (VREF)
unnamed: C49.1, U14.18 (CN)
unnamed: C50.1, U14.21 (CP)
unnamed: C54.1, R54.2, R55.1, U14.16 (FBN)
unnamed: C52.2, R58.2, R59.1, U14.22 (FBP)
unnamed: C44.1, R51.1, U14.4 (VIN), U14.9 (PSP), U14.11 (PSN)
unnamed: C48.1, R54.1, U14.17 (VREF)
unnamed: C60.2, U15.1 (BS)
unnamed: C61.2, R60.2, R61.1, U15.3 (FB)
unnamed: C60.1, L7.1, U15.6 (SW)

Notes on the sheet:
-3.99V
15.91V
8.00V
4.96V
-14.89V
-9.02V
1.99V
16.10V

Schematic: mcu.kicad_sch, Sitina 1 IO Board

Parts:
BZ1: Buzzer; Buzzer_CUI_CPT-9019S-SMT
C31, C67, C68, C92: 100nF; C_0402_1005Metric
C33: 10uF; C_0603_1608Metric
C63, C64, C65, C66: 18pF; C_0402_1005Metric
D2: LED; LED_0603_1608Metric
R14, R26: 22R; R_0402_1005Metric
R18: 10K; R_0402_1005Metric
R29: 1.5K; R_0402_1005Metric
R35: 200R; R_0402_1005Metric
R37: 1K; R_0402_1005Metric
U4: STM32F103C8Tx; LQFP-48_7x7mm_P0.5mm
Y1: 8MHz; Oscillator_SMD_Abracon_ASE-4Pin_3.2x2.5mm
Y2: 32.768K; Crystal_SMD_TXC_9HT11-2Pin_2.0x1.2mm_HandSoldering

Connections:
/mcu/BEEPER: R37.2, U4.14 (PA4)
/mcu/LED_G: U4.16 (PA6)
/mcu/LED_R: R35.1, U4.15 (PA5)
BODY_CS_LENS: U4.39 (PB3); also elsewhere on the board
BODY_VD_LENS: U4.19 (PB1); also elsewhere on the board
DCDC_EN: U4.13 (PA3); also elsewhere on the board
FAN_EN: U4.12 (PA2); also elsewhere on the board
FAN_PWM: U4.11 (PA1); also elsewhere on the board
FPGA_TCK: U4.42 (PB6); also elsewhere on the board
FPGA_TDI: U4.43 (PB7); also elsewhere on the board
FPGA_TDO: U4.45 (PB8); also elsewhere on the board
FPGA_TMS: U4.46 (PB9); also elsewhere on the board
GRIP_CS: U4.25 (PB12); also elsewhere on the board
GRIP_MISO: U4.27 (PB14); also elsewhere on the board
GRIP_MOSI: U4.28 (PB15); also elsewhere on the board
GRIP_SCK: U4.26 (PB13); also elsewhere on the board
I2C_SCL: U4.21 (PB10); also elsewhere on the board
I2C_SDA: U4.22 (PB11); also elsewhere on the board
LCD_EN: U4.38 (PA15); also elsewhere on the board
LCD_PWM: U4.29 (PA8); also elsewhere on the board
LENS_CS_BODY: U4.20 (PB2); also elsewhere on the board
LENS_DET: U4.40 (PB4); also elsewhere on the board
LENS_PWR_EN: U4.41 (PB5); also elsewhere on the board
LENS_RXD: U4.31 (PA10); also elsewhere on the board
LENS_TXD: U4.30 (PA9); also elsewhere on the board
MCU_SWCLK: U4.37 (PA14); also elsewhere on the board
MCU_SWDIO: U4.34 (PA13); also elsewhere on the board
unnamed: BZ1.1 (+), R37.1
unnamed: D2.2 (A), R35.2
unnamed: R14.2, U4.32 (PA11)
unnamed: R26.2, U4.33 (PA12)
unnamed: C65.2, U4.3 (PC14), Y2.1
unnamed: C63.1, U4.5 (PD0), Y1.1
unnamed: C64.1, U4.6 (PD1), Y1.3
PS_POR_B: U4.10 (PA0); also elsewhere on the board
USB_DN: R14.1; also elsewhere on the board
USB_DP: R26.1, R29.2; also elsewhere on the board

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
Board: 4 copper layers, 71.6 x 73.2 mm, 240 parts (72 on the bottom side), 160 nets.

Other parts of the board:
MICRO_SD1: MICRO_SD(TFC-WPAPR-08); TFC-WPAPR-08

Their connections:
+VSD: MICRO_SD1.4 (VDD); also elsewhere on the board
unnamed 84: MICRO_SD1.5 (CLK/SCLK); also elsewhere on the board
