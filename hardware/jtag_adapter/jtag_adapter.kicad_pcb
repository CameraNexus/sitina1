# Repository CameraNexus/sitina1 (continued)

## KiCad design Hardware/mainboard/pcb.kicad_pcb

Board: 4 copper layers, 71.6 x 73.2 mm, 198 parts (63 on the bottom side), 194 nets.

Parts:
C1, C8, C9, C69, C79, C95, C98, C99, C100, C101, C102: 22uF; C_0603_1608Metric
C2, C3, C11, C12, C13, C14, C16, C17, C19, C20, C33, C68, C82, C85, C86, C90, C91, C92, C105: 10uF; C_0603_1608Metric
C4, C6: 2.2uF; C_0402_1005Metric
C5, C37, C39, C41, C46, C49, C50, C53, C54, C56, C57, C59, C60, C62, C64, C88, C97: 220nF; C_0402_1005Metric
C7, C21, C23, C24, C70: 4.7uF; C_0402_1005Metric
C10, C22, C31, C40, C43, C44, C51, C52, C55, C58, C67, C71, C72, C73, C74, C75, C76, C77, C80, C83, C84, C87, C93, C94, C104: 100nF; C_0402_1005Metric
C15, C18: 1nF; C_0402_1005Metric
C25, C30, C63: 1uF; C_0402_1005Metric
C26, C27, C28, C29, C78: 18pF; C_0402_1005Metric
C32, C34, C35, C36, C45, C47, C48, C61, C66: 4.7uF; C_0603_1608Metric
C38, C65, C81: 470nF; C_0402_1005Metric
C42: 47uF; C_0603_1608Metric
C89: 1uF 25V; C_0603_1608Metric
C96: 47pF; C_0402_1005Metric
D1: B0530WS; D_SOD-323
D2: LED; LED_0603_1608Metric
D4: B0540W; D_SOD-323
FID1, FID2, FID3, FID4, FID5, FID6: Fiducial; Fiducial_0.75mm_Mask1.5mm
H1, H2, H3: MountingHole; MountingHole_2.2mm_M2_DIN965
J1, J9, J10, J11: 2.54mm pitch; PinSocket_1x02_P2.54mm_Vertical
J2: 02x04_P2.0; PinHeader_2x04_P2.00mm_Vertical_SMD
J3, J4: USB_C_Receptacle_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J5: FPC 0.5mm Bottom Contact; Hirose_FH12-30S-0.5SH_1x30-1MP_P0.50mm_Horizontal
J6: Hirose_FH12-45S-0.5SH_1x45-1MP_P0.50mm_Horizontal_Reversed
J7: FFC 0.5mm Bottom Contact; Hirose_FH12-12S-0.5SH_1x12-1MP_P0.50mm_Horizontal
J8: AudioJack2; Jack_2.5mm_PJ_210A
J12, J13, J14, J15, J16, J17, J18, J19, J20, J21: LensMount; YTC1P-4520
L1, L2, L3, L4, L8, L9: FTC201610S4R7MBCA; L_Murata_DFE201610P
L5: 22uH; L_1212
L6: EXC14CE900U; L_CommonModeChoke_Panasonic_EXC14CE
L7: 120R; L_0603_1608Metric
MICRO_SD1: MICRO_SD(TFC-WPAPR-08); TFC-WPAPR-08
R1, R2, R24: 1K; R_0402_1005Metric
R3: 200K; R_0402_1005Metric
R4, R7, R9, R12, R13, R14, R15, R21, R23, R28, R31, R32, R36: 10K; R_0402_1005Metric
R5: 30mR; R_0603_1608Metric
R6: 1; R_0603_1608Metric
R8, R35: 200R; R_0402_1005Metric
R10: 4.3K; R_0402_1005Metric
R11, R16: 36K; R_0402_1005Metric
R17: 22; R_0402_1005Metric
R18: 100K; R_0402_1005Metric
R19, R20, R26, R27: 5.1K 1%; R_0402_1005Metric
R22: 49.9K 1%; R_0402_1005Metric
R25: 7.5; R_0402_1005Metric
R29, R30: 49.9K/1%; R_0402_1005Metric
R33: 200K/1%; R_0402_1005Metric
R34: 27K/1%; R_0402_1005Metric
SW1: SW_Push_LED; TM-007-D1-X
U1: AXP209; QFN-48-1EP_6x6mm_P0.4mm_EP4.3x4.3mm_ThermalVias
U2: IMXRT1050; BGA-196_14x14_12.0x12.0mm
U3: MT48LC16M16A2BG; BGA-54_9x9_8.0x8.0mm
U4: W25Q32JV; WSON-8-1EP_6x5mm_P1.27mm_EP3.4x4.3mm
U5: STM32G030F6Px; TSSOP-20_4.4x6.5mm_P0.65mm
U6: CAT4139; SOT-23-5
U7: FODM3023; SMDIP-4_W7.62mm
U8: USBLC6-2P6; SOT-666
U9, U11: MT9700; SOT-23-5
U10: SY8120; TSOT-23-6
U12: SY7208; SOT-23-6
Y1: 24MHz; Oscillator_SMD_Abracon_ASE-4Pin_3.2x2.5mm
Y2: 32.768K; Crystal_SMD_TXC_9HT11-2Pin_2.0x1.2mm_HandSoldering

Connections:
+1V0: C30.1, C38.1, C42.1, C46.1, C50.1, C54.1, C60.1, C65.1, C66.1, L4.1, U2.F6 (VDD_SOC_IN), U2.F7 (VDD_SOC_IN), U2.F8 (VDD_SOC_IN), U2.F9 (VDD_SOC_IN), U2.G6 (VDD_SOC_IN), U2.G9 (VDD_SOC_IN), U2.H6 (VDD_SOC_IN), U2.H9 (VDD_SOC_IN), U2.J5 (DCDC_SENSE), U2.J9 (VDD_SOC_IN)
+1V8: C14.2, C15.2, C35.1, C43.1, C51.1, C69.1, C70.1, C71.1, C72.1, C73.1, C74.1, C75.1, C76.1, C77.1, L2.2, U1.10 (DCDC2), U2.E6 (NVCC_EMC), U2.F5 (NVCC_EMC), U3.A7 (VDDQ), U3.A9 (VDD), U3.B3 (VDDQ), U3.C7 (VDDQ), U3.D3 (VDDQ), U3.E7 (VDD), U3.J9 (VDD)
+3.3VA: C25.2, J5.29, J5.30, U1.11 (LDO4)
+3V3: C17.2, C18.2, C31.1, C33.1, C34.1, C36.1, C40.1, C41.1, C44.1, C45.1, C48.1, C49.1, C52.1, C53.1, C57.1, C58.1, C81.2, C82.2, C83.1, C84.1, C86.2, C87.2, C91.1, C93.2, J6.7 (VCI), J6.8 (IOVCC), J7.11, L3.2, L5.1, R4.1, R13.1, R15.1, R16.1, R18.1, U1.17 (DCDC3), U2.E9 (NVCC_GPIO), U2.F10 (NVCC_GPIO), U2.J10 (NVCC_GPIO), U2.K4 (DCDC_IN_Q), U2.K5 (NVCC_SD1), U2.L1 (DCDC_IN), U2.L2 (DCDC_IN), U2.P12 (VDD_HIGH_IN), U4.8 (VCC), U5.4 (VDD), U6.5 (IN), U10.5 (IN), U11.5 (VIN)
+3V3_LENS: C102.1, J16.1, U11.1 (VOUT)
+5VP: C85.1, C90.1, J3.A4 (VBUS), J3.A9 (VBUS), J3.B4 (VBUS), J3.B9 (VBUS), U1.32 (ACIN), U1.33 (ACIN)
+5V_LENS: C105.2, D1.1 (K), J13.1, R33.2
+BATT: C1.1, C9.1, C10.1, C11.2, J7.8, J7.9, J7.10, R5.2, U1.38 (BAT), U1.39 (BAT), U1.42 (BATSENSE)
+CCDPWR: C99.1, J2.1, J2.3, J2.5, J2.7, U9.1 (VOUT)
+FAN: C8.2, C95.1, C96.2, C98.2, C100.2, C101.2, J1.1, J9.1, J10.1, J11.1, L8.2, R11.2
+RTC: C23.2, C64.1, U1.28 (LDO1), U2.M9 (VDD_SNVS_IN)
+VCCIO_SD: C21.2, C55.1, C61.1, U1.41 (LDO3), U2.J6 (NVCC_SD0)
+VSD: C22.2, C79.1, C80.1, MICRO_SD1.4 (VDD), U1.12 (LDO2)
/cpu/BOOTMODE0: R12.2, U2.F11 (GPIO_AD_B0_04)
/cpu/BOOTMODE1: R9.2, U2.G14 (GPIO_AD_B0_05)
/cpu/JTAG_MOD: R7.1, U2.F13 (GPIO_AD_B0_08)
/cpu/VDDA_1P1_CAP: C39.1, C47.1, U2.P10 (NVCC_PLL)
/cpu/VDDA_2P5_CAP: C32.1, C37.1, U2.P8 (VDD_HIGH_CAP)
/ddr/SDRAM_A0: U2.C2 (GPIO_EMC_09), U3.H7 (A0)
/ddr/SDRAM_A1: U2.G1 (GPIO_EMC_10), U3.H8 (A1)
/ddr/SDRAM_A2: U2.G3 (GPIO_EMC_11), U3.J8 (A2)
/ddr/SDRAM_A3: U2.H1 (GPIO_EMC_12), U3.J7 (A3)
/ddr/SDRAM_A4: U2.A6 (GPIO_EMC_13), U3.J3 (A4)
/ddr/SDRAM_A5: U2.B6 (GPIO_EMC_14), U3.J2 (A5)
/ddr/SDRAM_A6: U2.B1 (GPIO_EMC_15), U3.H3 (A6)
/ddr/SDRAM_A7: U2.A5 (GPIO_EMC_16), U3.H2 (A7)
/ddr/SDRAM_A8: U2.A4 (GPIO_EMC_17), U3.H1 (A8)
/ddr/SDRAM_A9: U2.B2 (GPIO_EMC_18), U3.G3 (A9)
/ddr/SDRAM_A10: U2.G2 (GPIO_EMC_23), U3.H9 (A10)
/ddr/SDRAM_A11: U2.B4 (GPIO_EMC_19), U3.G2 (A11)
/ddr/SDRAM_A12: U2.A3 (GPIO_EMC_20), U3.G1 (A12)
/ddr/SDRAM_BA0: U2.C1 (GPIO_EMC_21), U3.G7 (BA0)
/ddr/SDRAM_BA1: U2.F1 (GPIO_EMC_22), U3.G8 (BA1)
/ddr/SDRAM_CAS: U2.D3 (GPIO_EMC_24), U3.F7 (~CAS)
/ddr/SDRAM_CKE: U2.A2 (GPIO_EMC_27), U3.F3 (CKE)
/ddr/SDRAM_CLK: U2.B3 (GPIO_EMC_26), U3.F2 (CLK)
/ddr/SDRAM_CS0: U2.E1 (GPIO_EMC_29), U3.G9 (~CS)
/ddr/SDRAM_D0: U2.E3 (GPIO_EMC_00), U3.A8 (DQ0)
/ddr/SDRAM_D1: U2.F3 (GPIO_EMC_01), U3.B9 (DQ1)
/ddr/SDRAM_D2: U2.F4 (GPIO_EMC_02), U3.B8 (DQ2)
/ddr/SDRAM_D3: U2.G4 (GPIO_EMC_03), U3.C9 (DQ3)
/ddr/SDRAM_D4: U2.F2 (GPIO_EMC_04), U3.C8 (DQ4)
/ddr/SDRAM_D5: U2.G5 (GPIO_EMC_05), U3.D9 (DQ5)
/ddr/SDRAM_D6: U2.H5 (GPIO_EMC_06), U3.D8 (DQ6)
/ddr/SDRAM_D7: U2.H4 (GPIO_EMC_07), U3.E9 (DQ7)
/ddr/SDRAM_D8: U2.C6 (GPIO_EMC_30), U3.E1 (DQ8)
/ddr/SDRAM_D9: U2.C5 (GPIO_EMC_31), U3.D2 (DQ9)
/ddr/SDRAM_D10: U2.D5 (GPIO_EMC_32), U3.D1 (DQ10)
/ddr/SDRAM_D11: U2.C4 (GPIO_EMC_33), U3.C2 (DQ11)
/ddr/SDRAM_D12: U2.D4 (GPIO_EMC_34), U3.C1 (DQ12)
/ddr/SDRAM_D13: U2.E5 (GPIO_EMC_35), U3.B2 (DQ13)
/ddr/SDRAM_D14: U2.C3 (GPIO_EMC_36), U3.B1 (DQ14)
/ddr/SDRAM_D15: U2.E4 (GPIO_EMC_37), U3.A2 (DQ15)
/ddr/SDRAM_DM0: U2.H3 (GPIO_EMC_08), U3.E8 (LDQM)
/ddr/SDRAM_DM1: U2.D6 (GPIO_EMC_38), U3.F1 (UDQM)
/ddr/SDRAM_RAS: U2.D2 (GPIO_EMC_25), U3.F8 (~RAS)
/ddr/SDRAM_WE: U2.D1 (GPIO_EMC_28), U3.F9 (~WE)
/lcd/LEDA: C89.2, D4.1 (K), J6.45 (LEDA)
/lcd/LEDK: J6.43 (LEDK), R24.1, R25.1
/mcu/FLASH_SYNC: R8.1, U5.15 (PB0/PB1/PB2/PA8)
/mcu/LED: R35.1, U5.3 (PC15)
/power/PWRLED: R2.1, U1.18 (GPIO1)
/power/PWRON: R1.1, U1.47 (PWRON)
/power/VINT: C4.1, U1.26 (VINT), U1.27 (LDO1SET)
/usb/USB1_DN: J4.A7 (D-), J4.B7 (D-), L6.1, U8.1 (I/O1), U8.6 (I/O1)
/usb/USB1_DP: J4.A6 (D+), J4.B6 (D+), L6.2, U8.3 (I/O2), U8.4 (I/O2)
AFE_RST: J5.24, U2.L12 (GPIO_AD_B1_04)
AFE_SCK: J5.23, U2.K12 (GPIO_AD_B1_05)
AFE_SDATA: J5.22, U2.K11 (GPIO_AD_B1_01)
AFE_SL: J5.21, U2.J12 (GPIO_AD_B1_06)
AFE_SYNC: J5.25, U2.K10 (GPIO_AD_B1_07)
BODY_CS_LENS: J20.1, U5.8 (PA1)
BODY_VD_LENS: J15.1, U5.12 (PA5)
CPU_SWCLK: J3.B8 (SBU2), U2.F12 (GPIO_AD_B0_07)
CPU_SWDIO: J3.A8 (SBU1), U2.E14 (GPIO_AD_B0_06)
CSI_D2: J5.2, U2.B13 (GPIO_B1_10)
CSI_D3: J5.3, U2.C13 (GPIO_B1_11)
CSI_D4: J5.4, U2.J14 (GPIO_AD_B1_15)
CSI_D5: J5.5, U2.G12 (GPIO_AD_B1_14)
CSI_D6: J5.6, U2.H11 (GPIO_AD_B1_13)
CSI_D7: J5.7, U2.H12 (GPIO_AD_B1_12)
CSI_D8: J5.8, U2.J13 (GPIO_AD_B1_11)
CSI_D9: J5.9, U2.L13 (GPIO_AD_B1_10)
CSI_D10: J5.10, U2.M13 (GPIO_AD_B1_09)
CSI_D11: J5.11, U2.H13 (GPIO_AD_B1_08)
CSI_D12: J5.12, U2.A13 (GPIO_B1_09)
CSI_D13: J5.13, U2.A12 (GPIO_B1_08)
CSI_D14: J5.14, U2.B12 (GPIO_B1_07)
CSI_D15: J5.15, U2.C12 (GPIO_B1_06)
CSI_HSYNC: J5.19, U2.C14 (GPIO_B1_14)
CSI_PIXCLK: J5.17, U2.D13 (GPIO_B1_12)
CSI_VSYNC: J5.18, U2.D14 (GPIO_B1_13)
DCDC_EN: R28.2, U5.1 (PB7/PB8), U9.4 (EN)
FAN_EN: R36.2, U5.2 (PC14/PB9), U10.4 (~SHDN)
FAN_PWM: R29.2, U5.13 (PA6)
FLASH_SYNC_S: J8.S, U7.4
FLASH_SYNC_T: J8.T, U7.3
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.1, C9.2, C10.2, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.2, C27.2, C28.1, C29.1, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, C61.2, C62.2, C63.2, C64.2, C65.2, C66.2, C67.2, C68.2, C69.2, C70.2, C71.2, C72.2, C73.2, C74.2, C75.2, C76.2, C77.2, C78.2, C79.2, C80.2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
GRIP_IO0: J7.1, U2.K14 (GPIO_AD_B0_12)
GRIP_IO1: J7.2, U2.L14 (GPIO_AD_B0_13)
GRIP_IO2: J7.3, U2.H14 (GPIO_AD_B0_14)
GRIP_IO3: J7.4, U2.J11 (GPIO_AD_B1_00)
I2C_SCL: J5.26, R15.2, U1.2 (SCK), U2.M3 (GPIO_SD_B1_02), U5.16 (PA11/PA9)
I2C_SDA: J5.27, R13.2, U1.1 (SDA), U2.P2 (GPIO_SD_B1_04), U5.17 (PA12/PA10)
IPSOUT: C3.1, C5.1, C13.2, C16.2, C19.2, C24.2, C104.2, L9.1, R6.1, U1.7 (VIN2), U1.14 (VIN3), U1.21 (APS), U1.29 (DC3SET), U1.34 (IPSOUT), U1.35 (IPSOUT), U1.40 (LDO3IN), U1.44 (VIN_CHG), U9.5 (VIN), U12.4 (EN), U12.5 (IN)
LCD_CLK: J6.39 (PCLK), U2.D7 (GPIO_B0_00)
LCD_CS: J6.12 (CS), U2.B14 (GPIO_B1_15)
LCD_D0: J6.35 (B2), U2.C8 (GPIO_B0_04)
LCD_D1: J6.34 (B3), U2.B8 (GPIO_B0_05)
LCD_D2: J6.33 (B4), U2.A8 (GPIO_B0_06)
LCD_D3: J6.32 (B5), U2.A9 (GPIO_B0_07)
LCD_D4: J6.31 (B6), J6.37 (B0), U2.B9 (GPIO_B0_08)
LCD_D5: J6.30 (B7), J6.36 (B1), U2.C9 (GPIO_B0_09)
LCD_D6: J6.27 (G2), U2.D9 (GPIO_B0_10)
LCD_D7: J6.26 (G3), U2.A10 (GPIO_B0_11)
LCD_D8: J6.25 (G4), U2.C10 (GPIO_B0_12)
LCD_D9: J6.24 (G5), U2.D10 (GPIO_B0_13)
LCD_D10: J6.23 (G6), J6.29 (G0), U2.E10 (GPIO_B0_14)
LCD_D11: J6.22 (G7), J6.28 (G1), U2.E11 (GPIO_B0_15)
LCD_D12: J6.19 (R2), U2.A11 (GPIO_B1_00)
LCD_D13: J6.18 (R3), U2.B11 (GPIO_B1_01)
LCD_D14: J6.17 (R4), U2.C11 (GPIO_B1_02)
LCD_D15: J6.16 (R5), U2.D11 (GPIO_B1_03)
LCD_D16: J6.15 (R6), J6.21 (R0), U2.E12 (GPIO_B1_04)
LCD_D17: J6.14 (R7), J6.20 (R1), U2.D12 (GPIO_B1_05)
LCD_DE: J6.38 (DE), U2.E7 (GPIO_B0_01)
LCD_EN: R21.1, U2.C7 (GPIO_EMC_41), U6.4 (~SHDN)
LCD_HSYNC: J6.40 (HSYNC), U2.E8 (GPIO_B0_02)
LCD_MOSI: J6.10 (SDI), U2.H10 (GPIO_AD_B0_01)
LCD_PWM: R22.2, U2.F14 (GPIO_AD_B0_09)
LCD_RST: J6.13 (RESET), U2.G11 (GPIO_AD_B0_03)
LCD_SCLK: J6.11 (SCL), U2.M14 (GPIO_AD_B0_00)
LCD_VSYNC: J6.41 (VSYNC), U2.D8 (GPIO_B0_03)
LENS_CS_BODY: J17.1, U5.7 (PA0)
LENS_DET: J21.1, U5.20 (PB3/PB4/PB5/PB6)
LENS_PWR_EN: R31.2, U5.11 (PA4), U11.4 (EN)
LENS_RXD: J18.1, U5.10 (PA3)
LENS_TXD: J19.1, U5.9 (PA2)
MCU_SWCLK: J4.B8 (SBU2), U5.19 (PA14/PA15)
MCU_SWDIO: J4.A8 (SBU1), U5.18 (PA13)
unnamed: C88.2, R22.1, R23.2
unnamed: C97.2, R29.1, R30.2
unnamed: D1.2 (A), L9.2, U12.1 (SW)
unnamed: D2.2 (A), R35.2
unnamed: D4.2 (A), L5.2, U6.1 (SW)
unnamed: J3.A5 (CC1), R19.1
unnamed: J3.B5 (CC2), R20.1
unnamed: J4.A5 (CC1), R26.1
unnamed: J4.B5 (CC2), R27.1
unnamed: L4.2, U2.M1 (DCDC_LP), U2.M2 (DCDC_LP)
unnamed: C78.1, MICRO_SD1.5 (CLK/SCLK), R17.1
unnamed: R1.2, SW1.2
unnamed: R8.2, U7.1
unnamed: R2.2, SW1.4 (A)
unnamed: R3.1, U1.23 (BIAS)
unnamed: C12.2, L1.2, R5.1, U1.43 (CHSENSE)
unnamed: C7.1, U1.19 (GPIO0/LDOIO0)
unnamed: C20.2, R6.2, U1.13 (LDO24IN)
unnamed: L2.1, U1.8 (LX2)
unnamed: L3.1, U1.15 (LX3)
unnamed: L1.1, U1.45 (LX_CHG)
unnamed: C6.1, U1.24 (VREF)
unnamed: C28.2, U2.N9 (RTC_XTALI), Y2.1
unnamed: C29.2, U2.P9 (RTC_XTALO), Y2.2
unnamed: C26.1, U2.P11 (XTALI), Y1.1
unnamed: C27.1, U2.N11 (XTALO), Y1.3
unnamed: C62.1, R16.2, U2.K3 (DCDC_PSWITCH)
unnamed: C56.1, C63.1, U2.N14 (VDDA_ADC_3P3)
unnamed: C59.1, U2.M10 (VDD_SNVS_CAP)
unnamed: C67.1, C68.1, U2.K8 (VDD_USB_CAP)
unnamed: R23.1, R24.2, U6.3 (FB)
unnamed: J4.A4 (VBUS), J4.A9 (VBUS), J4.B4 (VBUS), J4.B9 (VBUS), L7.2, U8.5 (VBUS)
unnamed: R10.2, U9.3 (SET)
unnamed: C94.2, U10.1 (BS)
unnamed: C96.1, R11.1, R14.2, R30.1, U10.3 (FB)
unnamed: C94.1, L8.1, U10.6 (SW)
unnamed: R32.2, U11.3 (SET)
unnamed: R33.1, R34.2, U12.3 (FB)
PWROK: R4.2, U1.25 (PWROK), U2.M7 (POR_B), U5.6 (NRST)
QSPI_DATA0: U2.P3 (GPIO_SD_B1_08), U4.5 (DI(IO0))
QSPI_DATA1: U2.N4 (GPIO_SD_B1_09), U4.2 (DO(IO1))
QSPI_DATA2: U2.P4 (GPIO_SD_B1_10), U4.3 (IO2)
QSPI_DATA3: U2.P5 (GPIO_SD_B1_11), U4.7 (IO3)
QSPI_SCLK: U2.L4 (GPIO_SD_B1_07), U4.6 (CLK)
QSPI_SS0: R18.2, U2.L3 (GPIO_SD_B1_06), U4.1 (~CS)
SD1_CLK: R17.2, U2.J3 (GPIO_SD_B0_01)
SD1_CMD: MICRO_SD1.3 (CMD/DI), U2.J4 (GPIO_SD_B0_00)
SD1_DATA0: MICRO_SD1.7 (DAT0/DO), U2.J1 (GPIO_SD_B0_02)
SD1_DATA1: MICRO_SD1.8 (DAT1/RES), U2.K1 (GPIO_SD_B0_03)
SD1_DATA2: MICRO_SD1.1 (DAT2/RES), U2.H2 (GPIO_SD_B0_04)
SD1_DATA3: MICRO_SD1.2 (CD/DAT3/CS), U2.J2 (GPIO_SD_B0_05)
USB_DN: L6.4, U2.M8 (USB_OTG1_DN)
USB_DP: L6.3, U2.L8 (USB_OTG1_DP)
VBUS: C2.1, C92.1, L7.1, U1.31 (VBUS), U2.N6 (USB_OTG1_VBUS)

## Code that names these connections

File firmware/mcu/sitina_mcu.ioc (part):

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Mcu.Name=STM32G030K(6-8)Tx
Mcu.Package=LQFP32
Mcu.UserName=STM32G030K6Tx
PA0.Signal=GPIO_Input
PA1.Signal=GPIO_Output
PA10.Mode=I2C
PA10.Signal=I2C1_SDA
PA11\ [PA9].Mode=I2C
PA11\ [PA9].Signal=I2C2_SCL
PA12\ [PA10].Mode=I2C
PA12\ [PA10].Signal=I2C2_SDA
PA13.Mode=Serial_Wire
PA13.Signal=SYS_SWDIO
PA14-BOOT0.Mode=Serial_Wire
PA14-BOOT0.Signal=SYS_SWCLK
PA15.Signal=GPIO_Input
PA2.Signal=USART2_TX
PA3.Signal=USART2_RX
PA4.Signal=GPIO_Output
PA5.Mode=Full_Duplex_Master
PA5.Signal=SPI1_SCK
PA6.Mode=Full_Duplex_Master
PA6.Signal=SPI1_MISO
PA7.Mode=Full_Duplex_Master
PA7.Signal=SPI1_MOSI
PA8.Signal=GPIO_Input
PA9.Mode=I2C
PA9.Signal=I2C1_SCL
PB0.Signal=GPIO_Output
PB1.Signal=GPIO_Output
PB2.Signal=GPIO_Output
PB3.Signal=S_TIM1_CH2
PB4.Signal=S_TIM3_CH1
PB5.Signal=GPIO_Output
PB6.Signal=GPIO_Output
PB7.Signal=GPIO_Output
PB8.Signal=GPIO_Output
PB9.Signal=GPIO_Output
PC14-OSC32_IN\ (PC14).Mode=LSE-External-Oscillator
PC14-OSC32_IN\ (PC14).Signal=RCC_OSC32_IN
PC15-OSC32_OUT\ (PC15).Mode=LSE-External-Oscillator
PC15-OSC32_OUT\ (PC15).Signal=RCC_OSC32_OUT
RCC.HSE_VALUE=8000000
RCC.SYSCLKFreq_VALUE=16000000
board=custom

File firmware/mcu/sitina_test.ioc (part):

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Mcu.Name=STM32F103C(8-B)Tx
Mcu.Package=LQFP48
Mcu.UserName=STM32F103C8Tx
PA0-WKUP.Signal=GPIO_Output
PA11.Mode=Device
PA11.Signal=USB_DM
PA12.Mode=Device
PA12.Signal=USB_DP
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PA15.Signal=GPIO_Output
PA2.Signal=GPIO_Output
PA3.Signal=GPIO_Output
PA5.Signal=GPIO_Output
PA8.Signal=S_TIM1_CH1
PB10.Mode=I2C
PB10.Signal=I2C2_SCL
PB11.Mode=I2C
PB11.Signal=I2C2_SDA
PB12.Signal=GPIO_Output
PB13.Mode=Full_Duplex_Master
PB13.Signal=SPI2_SCK
PB14.Mode=Full_Duplex_Master
PB14.Signal=SPI2_MISO
PB15.Mode=Full_Duplex_Master
PB15.Signal=SPI2_MOSI
PB6.Signal=GPIO_Output
PB7.Signal=GPIO_Output
PB8.Signal=GPIO_Input
PB9.Signal=GPIO_Output
PC14-OSC32_IN.Mode=LSE-External-Oscillator
PC14-OSC32_IN.Signal=RCC_OSC32_IN
PC15-OSC32_OUT.Mode=LSE-External-Oscillator
PC15-OSC32_OUT.Signal=RCC_OSC32_OUT
PD0-OSC_IN.Mode=HSE-External-Oscillator
PD0-OSC_IN.Signal=RCC_OSC_IN
PD1-OSC_OUT.Mode=HSE-External-Oscillator
PD1-OSC_OUT.Signal=RCC_OSC_OUT
RCC.SYSCLKFreq_VALUE=48000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

File Firmware/Target/board/pin_mux.c (part):

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processor_version: 11.0.1
pin_labels:
- {pin_num: M14, pin_signal: GPIO_AD_B0_00, label: SPI_SCK}
- {pin_num: H10, pin_signal: GPIO_AD_B0_01, label: SPI_MOSI}
- {pin_num: M11, pin_signal: GPIO_AD_B0_02, label: LCD2_RS}
- {pin_num: G11, pin_signal: GPIO_AD_B0_03, label: PERI_RST}
- {pin_num: M12, pin_signal: GPIO_AD_B1_03, label: SHUTTER}
- {pin_num: B14, pin_signal: GPIO_B1_15, label: LCD_CS}
- {pin_num: C7, pin_signal: GPIO_EMC_41, label: LCD_EN}
- {pin_num: A7, pin_signal: GPIO_EMC_40, label: AFE_SYNC}
- {pin_num: K14, pin_signal: GPIO_AD_B0_12, label: AFE_CS}
- {pin_num: F14, pin_signal: GPIO_AD_B0_09, label: USER1}
 * BE CAREFUL MODIFYING THIS COMMENT - IT IS YAML SETTINGS FOR TOOLS ***********
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  - {pin_num: A12, peripheral: CSI, signal: 'csi_data, 11', pin_signal: GPIO_B1_08}
  - {pin_num: B12, peripheral: CSI, signal: 'csi_data, 12', pin_signal: GPIO_B1_07}
  - {pin_num: C12, peripheral: CSI, signal: 'csi_data, 13', pin_signal: GPIO_B1_06}
  - {pin_num: C14, peripheral: CSI, signal: csi_hsync, pin_signal: GPIO_B1_14}
  - {pin_num: D14, peripheral: CSI, signal: csi_vsync, pin_signal: GPIO_B1_13}
  - {pin_num: D13, peripheral: CSI, signal: csi_pixclk, pin_signal: GPIO_B1_12}
  - {pin_num: D7, peripheral: LCDIF, signal: lcdif_clk, pin_signal: GPIO_B0_00, slew_rate: Fast}
  - {pin_num: C8, peripheral: LCDIF, signal: 'lcdif_data, 00', pin_signal: GPIO_B0_04, slew_rate: Fast}
  - {pin_num: B8, peripheral: LCDIF, signal: 'lcdif_data, 01', pin_signal: GPIO_B0_05, slew_rate: Fast}
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  - {pin_num: J2, peripheral: USDHC1, signal: 'usdhc_data, 3', pin_signal: GPIO_SD_B0_05}
  - {pin_num: J4, peripheral: USDHC1, signal: usdhc_cmd, pin_signal: GPIO_SD_B0_00}
  - {pin_num: J3, peripheral: USDHC1, signal: usdhc_clk, pin_signal: GPIO_SD_B0_01}
  - {pin_num: M14, peripheral: GPIO1, signal: 'gpio_io, 00', pin_signal: GPIO_AD_B0_00}
  - {pin_num: H10, peripheral: GPIO1, signal: 'gpio_io, 01', pin_signal: GPIO_AD_B0_01}
  - {pin_num: M11, peripheral: GPIO1, signal: 'gpio_io, 02', pin_signal: GPIO_AD_B0_02}
  - {pin_num: G11, peripheral: GPIO1, signal: 'gpio_io, 03', pin_signal: GPIO_AD_B0_03}
  - {pin_num: K11, peripheral: USDHC1, signal: usdhc_vselect, pin_signal: GPIO_AD_B1_01}
  - {pin_num: L11, peripheral: USDHC1, signal: usdhc_cd_b, pin_signal: GPIO_AD_B1_02}
  - {pin_num: M12, peripheral: GPIO1, signal: 'gpio_io, 19', pin_signal: GPIO_AD_B1_03}
  - {pin_num: B14, peripheral: GPIO2, signal: 'gpio_io, 31', pin_signal: GPIO_B1_15}
  - {pin_num: C7, peripheral: GPIO3, signal: 'gpio_io, 27', pin_signal: GPIO_EMC_41}
  - {pin_num: J13, peripheral: CSI, signal: 'csi_data, 06', pin_signal: GPIO_AD_B1_11}
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  - {pin_num: B7, peripheral: SEMC, signal: semc_dqs, pin_signal: GPIO_EMC_39, hysteresis_enable: Enable, speed: MHZ_200, drive_strength: R0_7, slew_rate: Fast}
  - {pin_num: D2, peripheral: SEMC, signal: semc_ras, pin_signal: GPIO_EMC_25, hysteresis_enable: Enable, speed: MHZ_200, drive_strength: R0_7, slew_rate: Fast}
  - {pin_num: D1, peripheral: SEMC, signal: semc_we, pin_signal: GPIO_EMC_28, hysteresis_enable: Enable, speed: MHZ_200, drive_strength: R0_7, slew_rate: Fast}
  - {pin_num: K14, peripheral: GPIO1, signal: 'gpio_io, 12', pin_signal: GPIO_AD_B0_12}
  - {pin_num: F14, peripheral: GPIO1, signal: 'gpio_io, 09', pin_signal: GPIO_AD_B0_09}
 * BE CAREFUL MODIFYING THIS COMMENT - IT IS YAML SETTINGS FOR TOOLS ***********
 */

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
## Commit log

2017-08-08 Inital schematic libraries
2017-10-21 Schematics: Add DDR
2017-10-26 Schematics: CCD H driver & AFE
2017-10-28 Schematics: Finish FPGA & CPU
2017-11-21 Add power section in schematics; Fix complie
2017-11-29 Update Design
2017-11-30 Going to refactor...
2017-12-01 Start layout
2017-12-02 Working on Layout
2017-12-04 Finish Layout
2017-12-06 Routing
2017-12-12 The Prototype Rev. 1
2017-12-15 Start designing FPGA code
2017-12-26 Running
2017-12-28 Add horizontal timing fsm
2018-01-05 Add ARM firmware barebone
2019-06-15 hw: add mcuxpresso project
2019-06-15 hw: migrate to kicad
2019-06-16 hw: draw sch for sdram
2019-06-16 hw: draw ad9990 symbol
2019-06-28 hw: working on afe
2020-08-31 readme: rename project
2020-08-31 pcb: align items to grid
2020-09-01 pcb: working on ccd schematics
2020-09-02 pcb: working on h-driver schematics
2020-09-03 pcb: working on h-driver and v-driver
2020-09-04 pcb: cleanup schematics; working on lcd
2020-09-07 pcb: working on power supply
2020-09-08 pcb: import footprints; finishing schematics
2020-09-19 pcb: remove outdated capture board design
2020-09-19 pcb: finishing overall design
2020-09-25 pcb: divide into two boards
2020-10-03 pcb: change footprint assignments
2020-10-09 pcb: start initial layouting
2020-10-12 pcb: working on layout
2020-11-17 pcb: move stuff around, add more capacitors
2020-11-18 pcb: wip
2020-11-19 fw: remove outdated fw
2021-03-17 Migrate to KiCAD 6, capture board layout changes
2021-03-17 Modify outline silkscreen
2021-03-27 PBr0p2, CBr0p1, submitted for prototype production
2021-03-27 Create firmware project stub
2021-03-31 Implement USB support, FB support, syslog support, 3rd party memory allocator
2021-04-01 Remove old KiCAD 5 files; Working on LCD driver and AFE driver; Restructure code
2021-04-03 Working on AFE driver
2021-04-07 Update License to match source code; test and fix USB, SEMC, and XIP on actual hardware
2021-04-11 pcb: bug fixes for PB r0.2
2021-04-21 Bug fixes and changes for PB r0p2
2021-08-15 pcb: switch to ad9978 wip
2021-08-15 Routing capture board in progress
2021-12-17 pcb: finish routing PB 0.2
2021-12-18 pcb: PB r0p2 and CB r0p3 freeze
2021-12-30 fw: fix semc/ initial ui/ fix lcd driver
2022-03-02 fw: working on afe driver; general fixes
2022-04-07 pcb: CB r0p4
2022-04-26 fw: working on bringing up the board
2022-04-26 fw: move target board files to a separate folder
2022-04-30 doc: update readme
2022-09-06 pcb: restructure, mb r0p5
2022-09-06 fw: poc afe driver working
2023-03-01 New PCB rev
2023-06-08 Initial bring-up of new rev
2023-07-13 AFE/CCD working on new rev hardware
2023-07-15 Image Viewer Working. The beginning of Effusus - the shared post processing library for SitinaNe
2023-07-15 Minor, Export PNG RGB888 via libpng
2023-07-20 Move power related function to separate file
2023-07-20 Enable SD card
2023-07-20 CCD shutter pulse fix and edge alignment adjust
2023-07-20 Update PCB files to rev 0.6 used for production
2023-07-21 Working towards pcb r0.7
2023-07-21 Fix battery charging
2023-07-22 Use dedicated LDO for 1.5V rail
2023-07-22 Fix vclock voltage shifter swing
2023-07-29 Add lvgl as submodule
2023-07-30 Initial PC sim
2023-07-30 Adjust V2_3rd edge alignment
2023-07-30 Update PC sim drivers, lvgl example working
2023-07-30 KAI1100x QE Plot
2023-08-02 Update CCD V Driver, New Powertree Documentation Page
2023-08-03 Initial implementation of camera hal for PC sim
2023-08-03 Port lvgl and hal layer to target hardware
2023-08-03 Remove lvgl submodule
2023-08-07 Switch to ugui
2023-08-09 Update AFE settings for draft readout mode
2023-08-10 Draft readout working
2023-08-10 Initial image processing support for draft readout
2023-08-11 Sync device firmware to PC sim; Implement variable shutter speed in draft mode in AFE driver
2023-08-11 Add terminus font
2023-08-11 Update GUI code to set ISO/ shutter speed
2023-08-13 Implement still image capture & corresponding UI
2023-08-13 Color LUT
2023-08-13 Implement preview display after capture
2023-08-13 Add title display in fw
2023-08-13 Save image sequence number
2023-08-13 Update MCUXpresso project
2023-08-13 Fix image seq read
2023-08-14 minor, added bayer raw output option
2023-08-19 Split sensor board out
2023-08-23 V Driver Patch Board
2023-08-23 Update Footprints & Symbols
2023-09-02 Power Board WIP
2023-09-04 Use pkg-config for detecting dependencies
2023-10-23 New mainboard rev wip
2023-11-23 Mainboard WIP
2023-11-23 Use relative path for 3D models
2023-11-23 Update sensor/power board outline
2023-11-24 Update power board outline
2023-11-24 Adding PowerBoard Schematic
2023-11-24 Update sensorboard outline and connector
2023-11-25 Update sensorboard to include heatsink
2023-11-25 PowerBoard Schematic, adding part values
2023-11-26 PowerBoard Floorplan
2023-11-26 Update powerboard 3d models
2023-11-26 Update mainboard design
2023-11-28 Power Board Routing WI{
2023-12-03 PowerBoard Alpha ver. Release
2023-12-11 PowerBoard DRC Clean
2023-12-14 mb sent for manufacturing
2023-12-18 CCD Sensor Board WIP
2023-12-19 Sensor Board WIP, minor
2023-12-19 Sensor Board Routing, First Pass Done, Ground Splitting TBD
2023-12-20 Sensor Board Routing Done
2023-12-26 Uploading Sensorboard Production Files
2023-12-27 minor
2024-02-16 Enclosure design wip
2024-02-22 Grip design wip
2024-02-28 Transiting to SW
2024-03-02 Enclosure WIP, adding models for new components
2024-03-05 Next set of PCB revisions WIP
2024-03-05 Update README and remove outdated files
2024-03-08 MB r0p8/ PB r0p2 routing in progress
2024-03-09 Use IPSOUT for lens 5V supply
2024-03-14 Design grip flex, SB/IOB WIP
2024-03-17 IOB r0p9 RC
2024-03-23 Sensorboard r0p9 routing done
2024-03-24 Revise board design to fit enclosure
2024-03-25 Enclosure design r0p9
2024-03-27 Hardware r0.9
2024-04-19 Rearrage files
2024-04-19 Transition to use pcb_common submodule
2024-05-10 USBC breakout board for JTAG, bug fix for grip flex cable
2024-05-10 Additional fixes for grip flex
2024-05-23 Import mulib as submodule
2024-05-23 Initial RTL setup
2024-05-27 Remove old AP firmware
2024-05-27 Initial checkin of MCU firmware
2024-05-27 Add verilog-axi as a submodule
2024-05-28 Power management enablement, experimental XVC bitbang function
2024-05-31 Working towards LCD bringup
2024-05-31 Import Vivado project
2024-05-31 Import AP Vitis project
2024-06-01 Initial CCD timing generator implementation
2024-06-03 Adding CCD VDriver QSPICE Simulation files
2024-06-04 Adding CCD VDriver QSPICE Simulation files, Adding Simulation of ONSemi's reference design
2024-06-05 PCB changes for r0p10
2024-06-09 Adiabatic driver initial commit
2024-06-09 PCB r0.10
2024-06-10 Enclosure update for r0p10
2024-06-10 PCB r0p10 release
2024-06-10 Adding CCD V Monitor Sample & Hold Schematic
2024-06-11 r0p11 sb pcb layout wip
2024-06-23 Post Processor Update: RGB565 dithering, gamma correction
2024-06-23 Post Processor Update: refactor
2024-06-23 Post Processor Update: Bugfix, adding tiff export
2024-07-04 Sensorboard r0p11 freeze
2024-07-04 Add log for old versions
2024-07-04 Formatting/typo fixes in OLD_VERSIONS.md
2024-07-19 V Driver RTL WIP
2024-07-20 V1 Driver RTL done, optimize for high speed clock
2024-07-23 Migrate to new Vitis for AP project
2024-07-23 Test key scan and LCD on MCU
2024-07-24 V Driver RTL update, implementing hybrid control for V2, adding ASCII figures of the PPG timing
2024-07-25 Finishing PPG RTL, adding PPG Testbench/Reference design with default timing parameters
2024-07-25 MCU firmware for IO board r0p10 and above
2024-07-25 Add standalone FSBL for JTAG flashing purpose
2024-07-25 AP firmware WIP for mulib DSI bringup
2024-07-25 Wire up DSI lite
2024-07-26 Revert adding JTAG FSBL
2024-07-27 Implement I2C comm between AP and MCU
2024-07-27 Migrate to Vitis 2024.1
2024-07-28 Initial implementation of GUI framework for AP
2024-07-28 Revert "Migrate to Vitis 2024.1"
    This reverts commit d05cfd6b809105f853f85ecff96089533746ac5a.
2024-07-28 Add binary for JTAG download per AR#70548
2024-07-31 Disable IOPLL clk2
2024-07-31 Implement driver for CCDTG/AFE/DCIF/PWM
2024-07-31 Wire up DCIF/PWM in the top level
2024-07-31 Add fps calculator
2024-08-01 Add backport version board
2024-08-01 Add KAI16000 calculation
2024-08-05 Add 2 rear buttons, add cutout for JTAG port, reduce tension spring thickness
2024-08-05 Add 2 more buttons on the grip flex
2024-08-05 Use header instead of pin for JTAG port on IOB
2024-08-05 Add JTAG breakout board
2024-08-12 Add left hand version of hardware
2024-08-15 Fix wrong part number for H driver
2024-08-21 Initial UI support for AON display
2024-08-21 Bump mulib for PHY and GPIO updates
2024-08-21 Basic image capturing working on new HW
2024-08-21 Rename os prefix to pal
2024-08-21 Fix FDG polarity; Update timing for 27MHz; Fix H frequency
2024-08-21 Checkin Vitis auto-generated/imported contents
2024-08-21 Implement button readback and framebuffer transfer on MCU
2024-08-21 Update constraints for MIPI
2024-08-21 Reduce PS clock frequency
2024-09-01 Initial color image processing implementation
2024-09-01 Hooking up input to GUI
2024-09-01 Make more control registers in CCDTG to be VSYNC updated
2024-09-01 Move portable sources into application folder so they are visible in Vitis IDE
2024-09-03 Move image processing to portable directory
2024-09-03 Allow VSYNC update in DCIF
2024-09-03 Set SDHCI frequency to 50M
2024-09-03 Use GUI on hardware build; working towards draft mode readout
2024-09-05 Regenerate Vitis project to update clock settings
2024-09-05 Working on basic camera features
2024-09-05 Implement basic power off feature
2024-09-08 Update post processing tool to read current file format
2024-09-08 Fix compiling on macOS
2024-09-08 Fix magic numbers in RAW reader
2024-09-19 Increase battery height, add left-handed version
2024-09-19 Remove print
2024-09-19 Reduce SDIO frequency
2024-09-19 Let simulator run with lower resolution
2024-09-28 Add a few sample photos
2024-09-28 Fix RAW offset
2024-09-28 Add discord link
2024-10-03 SB r0p12b WIP
2024-10-04 Reworking on power tree for SB
